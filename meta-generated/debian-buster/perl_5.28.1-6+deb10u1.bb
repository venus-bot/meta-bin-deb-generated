PACKAGES = "${PN} libperl5.28 perl perl-base perl-modules-5.28"
PROVIDES = "libperl5.28 perl perl-base perl-modules-5.28"
SRC_URI = " \
	http://ftp.de.debian.org/debian/pool/main/p/perl/libperl5.28_5.28.1-6+deb10u1_armhf.deb;unpack=0;name=deb0\
	http://ftp.de.debian.org/debian/pool/main/p/perl/perl_5.28.1-6+deb10u1_armhf.deb;unpack=0;name=deb1\
	http://ftp.de.debian.org/debian/pool/main/p/perl/perl-base_5.28.1-6+deb10u1_armhf.deb;unpack=0;name=deb2\
	http://ftp.de.debian.org/debian/pool/main/p/perl/perl-modules-5.28_5.28.1-6+deb10u1_all.deb;unpack=0;name=deb3\
"
DEBFILENAME_libperl5.28 = "libperl5.28_5.28.1-6+deb10u1_armhf.deb"
SRC_URI[deb0.sha256sum] = "aceb8d9a8e8d6234ee7c1f1ab699e3d847417da6804445346cff18b524132bdf"
SRC_URI[deb0.md5sum] = "9ece9755f1a494d2564fc4936af4deaf"
DEBFILENAME_perl = "perl_5.28.1-6+deb10u1_armhf.deb"
SRC_URI[deb1.sha256sum] = "fc610bd3769318580110b7c1a056214d47dbfccbfc82381a8563638c90f0e9a1"
SRC_URI[deb1.md5sum] = "a0fc6b7b09aba15acc845dd74a92c19e"
DEBFILENAME_perl-base = "perl-base_5.28.1-6+deb10u1_armhf.deb"
SRC_URI[deb2.sha256sum] = "e74ef211a025c42e22bfd958ad72a4b57af1091bf269d37ac87e7fb574ad16b4"
SRC_URI[deb2.md5sum] = "7ec9347171cf01a36fc7f54368a82908"
DEBFILENAME_perl-modules-5.28 = "perl-modules-5.28_5.28.1-6+deb10u1_all.deb"
SRC_URI[deb3.sha256sum] = "61c00b6f4c7a242aa6aefdc07012747607cd9c6c5392c1dcd087ce27031dd1dd"
SRC_URI[deb3.md5sum] = "949d474003add0721114ccffab808819"

RDEPENDS_lib${PN}5.28 = "libbz2-1.0 libc6 (>= 2.28) libdb5.3 libgdbm-compat4 (>= 1.18-3) libgdbm6 (>= 1.18-3) perl-modules-5.28 (>= 5.28.1-6+deb10u1) zlib1g (>= 1:1.2.2.3)"
RDEPENDS_${PN} = "dpkg (>= 1.17.17) libperl5.28 (= 5.28.1-6+deb10u1) perl-base (= 5.28.1-6+deb10u1) perl-modules-5.28 (>= 5.28.1-6+deb10u1)"
RDEPENDS_${PN}-base = "dpkg (>= 1.17.17) libc6 (>= 2.28)"
RDEPENDS_${PN}-modules-5.28 = "dpkg (>= 1.17.17) perl-base (>= 5.28.1-1)"
DEPENDS = "dpkg libbz2-1.0 libc6 libdb5.3 libgdbm-compat4 libgdbm6 zlib1g"


inherit deb_group

FILES_libperl5.28 = " \
    ./usr/bin/cpan5.28-arm-linux-gnueabihf \
    ./usr/bin/perl5.28-arm-linux-gnueabihf \
    ./usr/lib/arm-linux-gnueabihf/libperl.so.5.28 \
    ./usr/lib/arm-linux-gnueabihf/libperl.so.5.28.1 \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28 \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/B.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/B/Concise.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/B/Showlex.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/B/Terse.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/B/Xref.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/EXTERN.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/INTERN.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/XSUB.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/av.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/bitcount.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/charclass_invlists.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/config.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/cop.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/cv.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/dosish.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/dquote_inline.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/ebcdic_tables.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/embed.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/embedvar.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/fakesdio.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/feature.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/form.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/git_version.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/gv.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/handy.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/hv.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/hv_func.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/hv_macro.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/inline.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/intrpvar.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/invlist_inline.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/iperlsys.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/keywords.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/l1_char_class_tab.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/malloc_ctl.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/metaconfig.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/mg.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/mg_data.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/mg_raw.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/mg_vtable.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/mydtrace.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/nostdio.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/op.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/op_reg_common.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/opcode.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/opnames.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/overload.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/pad.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/parser.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/patchlevel-debian.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/patchlevel.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perl.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perl_inc_macro.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perl_langinfo.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perlapi.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perlio.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perliol.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perlsdio.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perlvars.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/perly.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/pp.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/pp_proto.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/proto.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/reentr.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/regcharclass.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/regcomp.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/regexp.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/regnodes.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/sbox32_hash.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/scope.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/stadtx_hash.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/sv.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/thread.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/time64.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/time64_config.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/uconfig.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/uni_keywords.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/unicode_constants.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/unixish.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/utf8.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/utfebcdic.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/util.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/uudmap.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/vutil.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/warnings.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/CORE/zaphod32_hash.h \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Compress/Raw/Bzip2.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Compress/Raw/Zlib.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Config.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Config.pod \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Config_git.pl \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Config_heavy.pl \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Cwd.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/DB_File.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Data/Dumper.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Devel/PPPort.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Devel/Peek.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Digest/MD5.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Digest/SHA.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/DynaLoader.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Alias.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Byte.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/CJKConstants.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/CN.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/CN/HZ.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Config.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/EBCDIC.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Encoder.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Encoding.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/GSM0338.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Guess.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/JP.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/JP/H2Z.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/JP/JIS7.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/KR.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/KR/2022_KR.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/MIME/Header.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/MIME/Header/ISO_2022_JP.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/MIME/Name.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Symbol.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/TW.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Unicode.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Encode/Unicode/UTF7.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Errno.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Fcntl.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/DosGlob.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Glob.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/AmigaOS.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/Cygwin.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/Epoc.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/Functions.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/Mac.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/OS2.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/Unix.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/VMS.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/File/Spec/Win32.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Filter/Util/Call.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/GDBM_File.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Hash/Util.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Hash/Util/FieldHash.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/I18N/Langinfo.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Dir.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/File.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Handle.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Pipe.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Poll.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Seekable.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Select.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Socket.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Socket/INET.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IO/Socket/UNIX.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IPC/Msg.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IPC/Semaphore.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IPC/SharedMem.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/IPC/SysV.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/List/Util.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/List/Util/XS.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/MIME/Base64.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/MIME/QuotedPrint.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Math/BigInt/FastCalc.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/NDBM_File.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/O.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/ODBM_File.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Opcode.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/POSIX.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/POSIX.pod \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/PerlIO/encoding.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/PerlIO/mmap.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/PerlIO/scalar.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/PerlIO/via.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/SDBM_File.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Scalar/Util.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Socket.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Storable.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Sub/Util.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Sys/Hostname.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Sys/Syslog.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Tie/Hash/NamedCapture.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Time/HiRes.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Time/Piece.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Time/Seconds.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Unicode/Collate.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Unicode/Collate/Locale.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/Unicode/Normalize.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/_h2ph_pre.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/arybase.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm-generic/bitsperlong.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm-generic/ioctl.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm-generic/ioctls.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm-generic/posix_types.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm-generic/socket.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm-generic/sockios.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm-generic/termbits.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm-generic/termios.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/bitsperlong.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/ioctl.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/ioctls.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/posix_types.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/sigcontext.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/socket.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/sockios.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/termbits.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/termios.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/unistd-common.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/unistd-eabi.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/unistd-oabi.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/asm/unistd.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/attributes.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/B/B.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Compress/Raw/Bzip2/Bzip2.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Compress/Raw/Zlib/Zlib.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Cwd/Cwd.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/DB_File/DB_File.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Data/Dumper/Dumper.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Devel/Peek/Peek.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Digest/MD5/MD5.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Digest/SHA/SHA.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/Byte/Byte.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/CN/CN.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/EBCDIC/EBCDIC.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/Encode.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/JP/JP.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/KR/KR.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/Symbol/Symbol.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/TW/TW.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Encode/Unicode/Unicode.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Fcntl/Fcntl.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/File/DosGlob/DosGlob.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/File/Glob/Glob.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Filter/Util/Call/Call.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/GDBM_File/GDBM_File.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Hash/Util/FieldHash/FieldHash.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Hash/Util/Util.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/I18N/Langinfo/Langinfo.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/IO/IO.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/IPC/SysV/SysV.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/List/Util/Util.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/MIME/Base64/Base64.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Math/BigInt/FastCalc/FastCalc.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/NDBM_File/NDBM_File.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/ODBM_File/ODBM_File.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Opcode/Opcode.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/POSIX/POSIX.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/PerlIO/encoding/encoding.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/PerlIO/mmap/mmap.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/PerlIO/scalar/scalar.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/PerlIO/via/via.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/SDBM_File/SDBM_File.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Socket/Socket.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Storable/Storable.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Sys/Hostname/Hostname.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Sys/Syslog/Syslog.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Tie/Hash/NamedCapture/NamedCapture.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Time/HiRes/HiRes.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Time/Piece/Piece.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Unicode/Collate/Collate.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/Unicode/Normalize/Normalize.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/arybase/arybase.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/attributes/attributes.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/mro/mro.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/re/re.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/threads/shared/shared.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/auto/threads/threads.so \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/byteswap.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/endian.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/ioctl-types.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/ioctls.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/long-double.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/pthreadtypes-arch.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/pthreadtypes.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/select.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/select2.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/sigaction.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/sigcontext.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/sigevent-consts.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/siginfo-arch.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/siginfo-consts-arch.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/siginfo-consts.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/signum-generic.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/signum.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/sigstack.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/sigthread.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/sockaddr.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/socket.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/socket2.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/socket_type.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/ss_flags.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/stdint-intn.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/syscall.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/syslog-ldbl.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/syslog-path.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/syslog.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/thread-shared-types.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/__sigset_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/__sigval_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/clock_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/clockid_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/sig_atomic_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/sigevent_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/siginfo_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/sigset_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/sigval_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/stack_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/struct_iovec.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/struct_osockaddr.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/struct_rusage.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/struct_sigstack.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/struct_timespec.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/struct_timeval.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/time_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/types/timer_t.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/typesizes.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/uintn-identity.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/waitflags.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/waitstatus.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/bits/wordsize.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/encoding.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/endian.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/errno.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/features.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/gnu/stubs-hard.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/gnu/stubs.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/lib.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/linux/ioctl.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/linux/posix_types.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/linux/stddef.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/mro.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/ops.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/re.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/signal.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/stdarg.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/stdc-predef.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/stddef.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/cdefs.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/ioctl.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/select.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/socket.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/syscall.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/syslog.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/time.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/ttydefaults.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/types.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/ucontext.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sys/wait.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/syscall.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/sysexits.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/syslimits.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/syslog.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/threads.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/threads/shared.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/5.28.1/wait.ph \
    ./usr/lib/arm-linux-gnueabihf/perl/cross-config-5.28.1/Config.pm \
    ./usr/lib/arm-linux-gnueabihf/perl/cross-config-5.28.1/Config_heavy.pl \
    ./usr/lib/arm-linux-gnueabihf/perl/debian-config-data-5.28.1/README \
    ./usr/lib/arm-linux-gnueabihf/perl/debian-config-data-5.28.1/config.sh.debug.gz \
    ./usr/lib/arm-linux-gnueabihf/perl/debian-config-data-5.28.1/config.sh.shared.gz \
    ./usr/lib/arm-linux-gnueabihf/perl/debian-config-data-5.28.1/config.sh.static.gz \
    ./usr/share/doc/libperl5.28/changelog.Debian.gz \
    ./usr/share/doc/libperl5.28/copyright \
    ./usr/share/man/man1/cpan5.28-arm-linux-gnueabihf.1.gz \
    ./usr/share/man/man1/perl5.28-arm-linux-gnueabihf.1.gz\
"
FILES_${PN} = " \
    ./etc/perl/Net/libnet.cfg \
    ./usr/bin/corelist \
    ./usr/bin/cpan \
    ./usr/bin/enc2xs \
    ./usr/bin/encguess \
    ./usr/bin/h2ph \
    ./usr/bin/h2xs \
    ./usr/bin/instmodsh \
    ./usr/bin/json_pp \
    ./usr/bin/libnetcfg \
    ./usr/bin/perlbug \
    ./usr/bin/perldoc \
    ./usr/bin/perlivp \
    ./usr/bin/perlthanks \
    ./usr/bin/piconv \
    ./usr/bin/pl2pm \
    ./usr/bin/pod2html \
    ./usr/bin/pod2man \
    ./usr/bin/pod2text \
    ./usr/bin/pod2usage \
    ./usr/bin/podchecker \
    ./usr/bin/podselect \
    ./usr/bin/prove \
    ./usr/bin/ptar \
    ./usr/bin/ptardiff \
    ./usr/bin/ptargrep \
    ./usr/bin/shasum \
    ./usr/bin/splain \
    ./usr/bin/xsubpp \
    ./usr/bin/zipdetails \
    ./usr/share/doc/perl/Changes.gz \
    ./usr/share/doc/perl/changelog.gz \
    ./usr/share/lintian/overrides/perl \
    ./usr/share/man/man1/corelist.1.gz \
    ./usr/share/man/man1/cpan.1.gz \
    ./usr/share/man/man1/enc2xs.1.gz \
    ./usr/share/man/man1/encguess.1.gz \
    ./usr/share/man/man1/h2ph.1.gz \
    ./usr/share/man/man1/h2xs.1.gz \
    ./usr/share/man/man1/instmodsh.1.gz \
    ./usr/share/man/man1/json_pp.1.gz \
    ./usr/share/man/man1/libnetcfg.1.gz \
    ./usr/share/man/man1/perlbug.1.gz \
    ./usr/share/man/man1/perlivp.1.gz \
    ./usr/share/man/man1/perlthanks.1.gz \
    ./usr/share/man/man1/piconv.1.gz \
    ./usr/share/man/man1/pl2pm.1.gz \
    ./usr/share/man/man1/pod2html.1.gz \
    ./usr/share/man/man1/pod2man.1.gz \
    ./usr/share/man/man1/pod2text.1.gz \
    ./usr/share/man/man1/pod2usage.1.gz \
    ./usr/share/man/man1/podchecker.1.gz \
    ./usr/share/man/man1/podselect.1.gz \
    ./usr/share/man/man1/prove.1.gz \
    ./usr/share/man/man1/ptar.1.gz \
    ./usr/share/man/man1/ptardiff.1.gz \
    ./usr/share/man/man1/ptargrep.1.gz \
    ./usr/share/man/man1/shasum.1.gz \
    ./usr/share/man/man1/splain.1.gz \
    ./usr/share/man/man1/xsubpp.1.gz \
    ./usr/share/man/man1/zipdetails.1.gz\
"
FILES_perl-base = " \
    ./usr/bin/perl \
    ./usr/bin/perl5.28.1 \
    ./usr/lib/arm-linux-gnueabihf/perl-base/AutoLoader.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Carp.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Carp/Heavy.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Config.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Config_git.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Config_heavy.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Cwd.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/DynaLoader.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Errno.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Exporter.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Exporter/Heavy.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Fcntl.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/File/Basename.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/File/Glob.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/File/Path.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/File/Spec.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/File/Spec/Unix.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/File/Temp.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/FileHandle.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Getopt/Long.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Hash/Util.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/File.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/Handle.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/Pipe.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/Seekable.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/Select.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/Socket.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/Socket/INET.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/Socket/IP.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IO/Socket/UNIX.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IPC/Open2.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/IPC/Open3.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/List/Util.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/POSIX.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Scalar/Util.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/SelectSaver.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Socket.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Symbol.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Text/ParseWords.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Text/Tabs.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Text/Wrap.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/Tie/Hash.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/XSLoader.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/attributes.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/Cwd/Cwd.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/Fcntl/Fcntl.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/File/Glob/Glob.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/Hash/Util/Util.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/IO/IO.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/List/Util/Util.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/POSIX/POSIX.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/Socket/Socket.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/attributes/attributes.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/auto/re/re.so \
    ./usr/lib/arm-linux-gnueabihf/perl-base/base.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/bytes.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/bytes_heavy.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/constant.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/feature.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/fields.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/integer.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/lib.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/locale.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/overload.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/overloading.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/parent.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/re.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/strict.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/Heavy.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Age.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Bc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Bmg.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Bpb.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Bpt.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Cf.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Digit.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Ea.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Fold.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/GCB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Gc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Hst.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/InPC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/InSC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Isc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Jg.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Jt.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Lb.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Lc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Lower.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/NFCQC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/NFDQC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/NFKCCF.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/NFKCQC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/NFKDQC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Na1.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/NameAlia.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Nt.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Nv.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/PerlDeci.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/SB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Sc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Scx.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Tc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Title.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Uc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Upper.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/Vo.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/WB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/_PerlLB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/_PerlSCX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/To/_PerlWB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/NA.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V100.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V11.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V20.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V30.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V31.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V32.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V40.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V41.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V50.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V51.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V52.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V60.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V61.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V70.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V80.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Age/V90.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Alpha/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/AL.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/AN.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/B.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/BN.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/CS.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/EN.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/ES.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/ET.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/L.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/NSM.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/ON.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/R.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bc/WS.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/BidiC/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/BidiM/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Blk/NB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bpt/C.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bpt/N.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Bpt/O.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CE/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CI/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CWCF/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CWCM/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CWKCF/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CWL/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CWT/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CWU/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Cased/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/A.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/AL.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/AR.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/ATAR.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/B.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/BR.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/DB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/NK.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/NR.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/OV.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ccc/VR.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/CompEx/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/DI/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dash/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dep/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dia/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Com.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Enc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Fin.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Font.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Init.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Iso.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Med.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Nar.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Nb.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/NonCanon.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Sqr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Sub.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Sup.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Dt/Vert.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ea/A.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ea/H.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ea/N.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ea/Na.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ea/W.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ext/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/CN.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/EB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/EX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/GAZ.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/LV.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/LVT.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/PP.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/SM.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GCB/XX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/C.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Cf.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Cn.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/L.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/LC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Ll.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Lm.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Lo.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Lu.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/M.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Mc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Me.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Mn.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/N.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Nd.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Nl.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/No.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/P.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Pc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Pd.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Pe.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Pf.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Pi.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Po.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Ps.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/S.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Sc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Sk.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Sm.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/So.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Z.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Gc/Zs.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/GrBase/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Hex/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Hst/NA.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Hyphen/T.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/IDC/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/IDS/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Ideo/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/10_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/2_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/2_1.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/3_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/3_1.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/3_2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/4_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/4_1.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/5_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/5_1.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/5_2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/6_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/6_1.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/6_2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/6_3.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/7_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/8_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/In/9_0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/Bottom.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/Left.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/LeftAndR.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/NA.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/Overstru.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/Right.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/Top.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/TopAndBo.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/TopAndL2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/TopAndLe.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/TopAndRi.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InPC/VisualOr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Avagraha.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Bindu.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Cantilla.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Consona2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Consona3.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Consona4.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Consona5.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Consona6.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Consonan.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Invisibl.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Nukta.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Number.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Other.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/PureKill.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Syllable.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/ToneMark.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Virama.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Visarga.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/Vowel.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/VowelDep.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/InSC/VowelInd.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Ain.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Alef.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Beh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Dal.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/FarsiYeh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Feh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Gaf.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Hah.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Kaf.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Lam.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/NoJoinin.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Qaf.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Reh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Sad.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Seen.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Waw.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jg/Yeh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jt/C.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jt/D.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jt/R.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jt/T.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Jt/U.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/AI.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/AL.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/BA.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/BB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/CJ.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/CL.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/CM.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/EB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/EX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/GL.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/ID.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/IN.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/IS.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/NS.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/OP.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/PO.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/PR.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/QU.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/SA.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lb/XX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Lower/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Math/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/NFCQC/M.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/NFCQC/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/NFDQC/N.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/NFDQC/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/NFKCQC/N.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/NFKCQC/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/NFKDQC/N.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/NFKDQC/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nt/Di.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nt/None.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nt/Nu.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/0.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/1.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/10.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/100.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/1000.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/10000.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/11.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/12.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/13.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/14.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/15.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/16.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/17.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/18.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/19.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/1_16.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/1_2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/1_3.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/1_4.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/1_8.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/20.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/200.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/2_3.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/3.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/30.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/300.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/3_16.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/3_4.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/4.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/40.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/400.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/5.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/50.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/500.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/5000.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/50000.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/6.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/60.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/600.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/7.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/70.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/700.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/8.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/80.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/800.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/9.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/90.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Nv/900.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/PCM/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/PatSyn/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/Alnum.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/Assigned.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/Blank.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/Graph.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/PerlWord.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/PosixPun.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/Print.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/SpacePer.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/Title.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/Word.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/XPosixPu.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlAny.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlCh2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlCha.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlFol.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlIDC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlIDS.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlNch.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlPat.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlPr2.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlPro.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Perl/_PerlQuo.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/QMark/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/AT.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/CL.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/EX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/FO.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/LE.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/LO.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/NU.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/SC.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/ST.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/Sp.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/UP.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SB/XX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/SD/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/STerm/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Arab.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Armn.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Beng.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Cprt.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Cyrl.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Deva.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Dupl.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Geor.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Glag.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Gran.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Grek.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Gujr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Guru.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Han.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Hang.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Hira.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Kana.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Knda.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Latn.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Limb.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Linb.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Mlym.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Mong.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Mult.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Orya.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Sinh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Syrc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Taml.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Telu.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Zinh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Sc/Zyyy.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Adlm.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Arab.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Armn.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Beng.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Bhks.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Bopo.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Cakm.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Cham.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Copt.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Cprt.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Cyrl.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Deva.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Dupl.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Ethi.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Geor.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Glag.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Gonm.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Gran.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Grek.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Gujr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Guru.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Han.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Hang.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Hebr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Hira.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Hmng.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Kana.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Khar.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Khmr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Knda.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Lana.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Lao.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Latn.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Limb.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Lina.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Linb.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Mlym.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Mong.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Mult.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Mymr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Orya.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Phlp.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Shrd.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Sind.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Sinh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Syrc.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Tagb.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Takr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Talu.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Taml.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Telu.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Thaa.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Tibt.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Tirh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Xsux.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Yi.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Zinh.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Zyyy.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Scx/Zzzz.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Term/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/UIdeo/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Upper/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Vo/R.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Vo/Tr.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Vo/Tu.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/Vo/U.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/EX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/Extend.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/FO.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/HL.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/KA.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/LE.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/MB.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/ML.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/MN.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/NU.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/WB/XX.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/XIDC/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/unicore/lib/XIDS/Y.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/utf8.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/utf8_heavy.pl \
    ./usr/lib/arm-linux-gnueabihf/perl-base/vars.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/warnings.pm \
    ./usr/lib/arm-linux-gnueabihf/perl-base/warnings/register.pm \
    ./usr/share/doc/perl-base \
    ./usr/share/doc/perl/AUTHORS.gz \
    ./usr/share/doc/perl/Documentation \
    ./usr/share/doc/perl/README.Debian \
    ./usr/share/doc/perl/changelog.Debian.gz \
    ./usr/share/doc/perl/copyright \
    ./usr/share/lintian/overrides/perl-base \
    ./usr/share/man/man1/perl.1.gz \
    ./usr/share/man/man1/perl5.28.1.1.gz\
"
FILES_perl-modules-5.28 = " \
    ./usr/share/doc/perl-modules-5.28/README.Debian \
    ./usr/share/doc/perl-modules-5.28/changelog.Debian.gz \
    ./usr/share/doc/perl-modules-5.28/copyright \
    ./usr/share/lintian/overrides/perl-modules-5.28 \
    ./usr/share/perl/5.28 \
    ./usr/share/perl/5.28.1/AnyDBM_File.pm \
    ./usr/share/perl/5.28.1/App/Cpan.pm \
    ./usr/share/perl/5.28.1/App/Prove.pm \
    ./usr/share/perl/5.28.1/App/Prove/State.pm \
    ./usr/share/perl/5.28.1/App/Prove/State/Result.pm \
    ./usr/share/perl/5.28.1/App/Prove/State/Result/Test.pm \
    ./usr/share/perl/5.28.1/Archive/Tar.pm \
    ./usr/share/perl/5.28.1/Archive/Tar/Constant.pm \
    ./usr/share/perl/5.28.1/Archive/Tar/File.pm \
    ./usr/share/perl/5.28.1/Attribute/Handlers.pm \
    ./usr/share/perl/5.28.1/AutoLoader.pm \
    ./usr/share/perl/5.28.1/AutoSplit.pm \
    ./usr/share/perl/5.28.1/B/Debug.pm \
    ./usr/share/perl/5.28.1/B/Deparse.pm \
    ./usr/share/perl/5.28.1/B/Op_private.pm \
    ./usr/share/perl/5.28.1/Benchmark.pm \
    ./usr/share/perl/5.28.1/CORE.pod \
    ./usr/share/perl/5.28.1/CPAN.pm \
    ./usr/share/perl/5.28.1/CPAN/API/HOWTO.pod \
    ./usr/share/perl/5.28.1/CPAN/Author.pm \
    ./usr/share/perl/5.28.1/CPAN/Bundle.pm \
    ./usr/share/perl/5.28.1/CPAN/CacheMgr.pm \
    ./usr/share/perl/5.28.1/CPAN/Complete.pm \
    ./usr/share/perl/5.28.1/CPAN/Debug.pm \
    ./usr/share/perl/5.28.1/CPAN/DeferredCode.pm \
    ./usr/share/perl/5.28.1/CPAN/Distribution.pm \
    ./usr/share/perl/5.28.1/CPAN/Distroprefs.pm \
    ./usr/share/perl/5.28.1/CPAN/Distrostatus.pm \
    ./usr/share/perl/5.28.1/CPAN/Exception/RecursiveDependency.pm \
    ./usr/share/perl/5.28.1/CPAN/Exception/blocked_urllist.pm \
    ./usr/share/perl/5.28.1/CPAN/Exception/yaml_not_installed.pm \
    ./usr/share/perl/5.28.1/CPAN/Exception/yaml_process_error.pm \
    ./usr/share/perl/5.28.1/CPAN/FTP.pm \
    ./usr/share/perl/5.28.1/CPAN/FTP/netrc.pm \
    ./usr/share/perl/5.28.1/CPAN/FirstTime.pm \
    ./usr/share/perl/5.28.1/CPAN/HTTP/Client.pm \
    ./usr/share/perl/5.28.1/CPAN/HTTP/Credentials.pm \
    ./usr/share/perl/5.28.1/CPAN/HandleConfig.pm \
    ./usr/share/perl/5.28.1/CPAN/Index.pm \
    ./usr/share/perl/5.28.1/CPAN/InfoObj.pm \
    ./usr/share/perl/5.28.1/CPAN/Kwalify.pm \
    ./usr/share/perl/5.28.1/CPAN/Kwalify/distroprefs.dd \
    ./usr/share/perl/5.28.1/CPAN/Kwalify/distroprefs.yml \
    ./usr/share/perl/5.28.1/CPAN/LWP/UserAgent.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/Converter.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/Feature.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/History.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/History/Meta_1_0.pod \
    ./usr/share/perl/5.28.1/CPAN/Meta/History/Meta_1_1.pod \
    ./usr/share/perl/5.28.1/CPAN/Meta/History/Meta_1_2.pod \
    ./usr/share/perl/5.28.1/CPAN/Meta/History/Meta_1_3.pod \
    ./usr/share/perl/5.28.1/CPAN/Meta/History/Meta_1_4.pod \
    ./usr/share/perl/5.28.1/CPAN/Meta/Merge.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/Prereqs.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/Requirements.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/Spec.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/Validator.pm \
    ./usr/share/perl/5.28.1/CPAN/Meta/YAML.pm \
    ./usr/share/perl/5.28.1/CPAN/Mirrors.pm \
    ./usr/share/perl/5.28.1/CPAN/Module.pm \
    ./usr/share/perl/5.28.1/CPAN/Nox.pm \
    ./usr/share/perl/5.28.1/CPAN/Plugin.pm \
    ./usr/share/perl/5.28.1/CPAN/Plugin/Specfile.pm \
    ./usr/share/perl/5.28.1/CPAN/Prompt.pm \
    ./usr/share/perl/5.28.1/CPAN/Queue.pm \
    ./usr/share/perl/5.28.1/CPAN/Shell.pm \
    ./usr/share/perl/5.28.1/CPAN/Tarzip.pm \
    ./usr/share/perl/5.28.1/CPAN/URL.pm \
    ./usr/share/perl/5.28.1/CPAN/Version.pm \
    ./usr/share/perl/5.28.1/Carp.pm \
    ./usr/share/perl/5.28.1/Carp/Heavy.pm \
    ./usr/share/perl/5.28.1/Class/Struct.pm \
    ./usr/share/perl/5.28.1/Compress/Zlib.pm \
    ./usr/share/perl/5.28.1/Config/Extensions.pm \
    ./usr/share/perl/5.28.1/Config/Perl/V.pm \
    ./usr/share/perl/5.28.1/DB.pm \
    ./usr/share/perl/5.28.1/DBM_Filter.pm \
    ./usr/share/perl/5.28.1/DBM_Filter/compress.pm \
    ./usr/share/perl/5.28.1/DBM_Filter/encode.pm \
    ./usr/share/perl/5.28.1/DBM_Filter/int32.pm \
    ./usr/share/perl/5.28.1/DBM_Filter/null.pm \
    ./usr/share/perl/5.28.1/DBM_Filter/utf8.pm \
    ./usr/share/perl/5.28.1/Devel/SelfStubber.pm \
    ./usr/share/perl/5.28.1/Digest.pm \
    ./usr/share/perl/5.28.1/Digest/base.pm \
    ./usr/share/perl/5.28.1/Digest/file.pm \
    ./usr/share/perl/5.28.1/DirHandle.pm \
    ./usr/share/perl/5.28.1/Dumpvalue.pm \
    ./usr/share/perl/5.28.1/Encode/Changes.e2x \
    ./usr/share/perl/5.28.1/Encode/ConfigLocal_PM.e2x \
    ./usr/share/perl/5.28.1/Encode/Makefile_PL.e2x \
    ./usr/share/perl/5.28.1/Encode/PerlIO.pod \
    ./usr/share/perl/5.28.1/Encode/README.e2x \
    ./usr/share/perl/5.28.1/Encode/Supported.pod \
    ./usr/share/perl/5.28.1/Encode/_PM.e2x \
    ./usr/share/perl/5.28.1/Encode/_T.e2x \
    ./usr/share/perl/5.28.1/Encode/encode.h \
    ./usr/share/perl/5.28.1/English.pm \
    ./usr/share/perl/5.28.1/Env.pm \
    ./usr/share/perl/5.28.1/Exporter.pm \
    ./usr/share/perl/5.28.1/Exporter/Heavy.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Base.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/Unix.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/VMS.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/Windows.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/Windows/BCC.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/Windows/GCC.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/Windows/MSVC.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/aix.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/android.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/cygwin.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/darwin.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/dec_osf.pm \
    ./usr/share/perl/5.28.1/ExtUtils/CBuilder/Platform/os2.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Command.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Command/MM.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Constant.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Constant/Base.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Constant/ProxySubs.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Constant/Utils.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Constant/XS.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Embed.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Install.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Installed.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Liblist.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Liblist/Kid.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MANIFEST.SKIP \
    ./usr/share/perl/5.28.1/ExtUtils/MM.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_AIX.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_Any.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_BeOS.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_Cygwin.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_DOS.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_Darwin.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_MacOS.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_NW5.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_OS2.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_QNX.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_UWIN.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_Unix.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_VMS.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_VOS.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_Win32.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MM_Win95.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MY.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MakeMaker.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MakeMaker/Config.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MakeMaker/FAQ.pod \
    ./usr/share/perl/5.28.1/ExtUtils/MakeMaker/Locale.pm \
    ./usr/share/perl/5.28.1/ExtUtils/MakeMaker/Tutorial.pod \
    ./usr/share/perl/5.28.1/ExtUtils/MakeMaker/version.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Manifest.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Miniperl.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Mkbootstrap.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Mksymlists.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Packlist.pm \
    ./usr/share/perl/5.28.1/ExtUtils/ParseXS.pm \
    ./usr/share/perl/5.28.1/ExtUtils/ParseXS.pod \
    ./usr/share/perl/5.28.1/ExtUtils/ParseXS/Constants.pm \
    ./usr/share/perl/5.28.1/ExtUtils/ParseXS/CountLines.pm \
    ./usr/share/perl/5.28.1/ExtUtils/ParseXS/Eval.pm \
    ./usr/share/perl/5.28.1/ExtUtils/ParseXS/Utilities.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Typemaps.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Typemaps/Cmd.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Typemaps/InputMap.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Typemaps/OutputMap.pm \
    ./usr/share/perl/5.28.1/ExtUtils/Typemaps/Type.pm \
    ./usr/share/perl/5.28.1/ExtUtils/testlib.pm \
    ./usr/share/perl/5.28.1/ExtUtils/typemap \
    ./usr/share/perl/5.28.1/ExtUtils/xsubpp \
    ./usr/share/perl/5.28.1/Fatal.pm \
    ./usr/share/perl/5.28.1/File/Basename.pm \
    ./usr/share/perl/5.28.1/File/Compare.pm \
    ./usr/share/perl/5.28.1/File/Copy.pm \
    ./usr/share/perl/5.28.1/File/Fetch.pm \
    ./usr/share/perl/5.28.1/File/Find.pm \
    ./usr/share/perl/5.28.1/File/GlobMapper.pm \
    ./usr/share/perl/5.28.1/File/Path.pm \
    ./usr/share/perl/5.28.1/File/Temp.pm \
    ./usr/share/perl/5.28.1/File/stat.pm \
    ./usr/share/perl/5.28.1/FileCache.pm \
    ./usr/share/perl/5.28.1/FileHandle.pm \
    ./usr/share/perl/5.28.1/Filter/Simple.pm \
    ./usr/share/perl/5.28.1/FindBin.pm \
    ./usr/share/perl/5.28.1/Getopt/Long.pm \
    ./usr/share/perl/5.28.1/Getopt/Std.pm \
    ./usr/share/perl/5.28.1/HTTP/Tiny.pm \
    ./usr/share/perl/5.28.1/I18N/Collate.pm \
    ./usr/share/perl/5.28.1/I18N/LangTags.pm \
    ./usr/share/perl/5.28.1/I18N/LangTags/Detect.pm \
    ./usr/share/perl/5.28.1/I18N/LangTags/List.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Adapter/Bzip2.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Adapter/Deflate.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Adapter/Identity.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Base.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Base/Common.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Bzip2.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Deflate.pm \
    ./usr/share/perl/5.28.1/IO/Compress/FAQ.pod \
    ./usr/share/perl/5.28.1/IO/Compress/Gzip.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Gzip/Constants.pm \
    ./usr/share/perl/5.28.1/IO/Compress/RawDeflate.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Zip.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Zip/Constants.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Zlib/Constants.pm \
    ./usr/share/perl/5.28.1/IO/Compress/Zlib/Extra.pm \
    ./usr/share/perl/5.28.1/IO/Socket/IP.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/Adapter/Bunzip2.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/Adapter/Identity.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/Adapter/Inflate.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/AnyInflate.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/AnyUncompress.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/Base.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/Bunzip2.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/Gunzip.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/Inflate.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/RawInflate.pm \
    ./usr/share/perl/5.28.1/IO/Uncompress/Unzip.pm \
    ./usr/share/perl/5.28.1/IO/Zlib.pm \
    ./usr/share/perl/5.28.1/IPC/Cmd.pm \
    ./usr/share/perl/5.28.1/IPC/Open2.pm \
    ./usr/share/perl/5.28.1/IPC/Open3.pm \
    ./usr/share/perl/5.28.1/Internals.pod \
    ./usr/share/perl/5.28.1/JSON/PP.pm \
    ./usr/share/perl/5.28.1/JSON/PP/Boolean.pm \
    ./usr/share/perl/5.28.1/Locale/Codes.pm \
    ./usr/share/perl/5.28.1/Locale/Codes.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/Changes.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/Constants.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Country.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Country.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/Country_Codes.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Country_Retired.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Currency.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Currency.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/Currency_Codes.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Currency_Retired.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangExt.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangExt.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/LangExt_Codes.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangExt_Retired.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangFam.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangFam.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/LangFam_Codes.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangFam_Retired.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangVar.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangVar.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/LangVar_Codes.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/LangVar_Retired.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Language.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Language.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/Language_Codes.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Language_Retired.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Script.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Script.pod \
    ./usr/share/perl/5.28.1/Locale/Codes/Script_Codes.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Script_Retired.pm \
    ./usr/share/perl/5.28.1/Locale/Codes/Types.pod \
    ./usr/share/perl/5.28.1/Locale/Country.pm \
    ./usr/share/perl/5.28.1/Locale/Country.pod \
    ./usr/share/perl/5.28.1/Locale/Currency.pm \
    ./usr/share/perl/5.28.1/Locale/Currency.pod \
    ./usr/share/perl/5.28.1/Locale/Language.pm \
    ./usr/share/perl/5.28.1/Locale/Language.pod \
    ./usr/share/perl/5.28.1/Locale/Maketext.pm \
    ./usr/share/perl/5.28.1/Locale/Maketext.pod \
    ./usr/share/perl/5.28.1/Locale/Maketext/Cookbook.pod \
    ./usr/share/perl/5.28.1/Locale/Maketext/Guts.pm \
    ./usr/share/perl/5.28.1/Locale/Maketext/GutsLoader.pm \
    ./usr/share/perl/5.28.1/Locale/Maketext/Simple.pm \
    ./usr/share/perl/5.28.1/Locale/Maketext/TPJ13.pod \
    ./usr/share/perl/5.28.1/Locale/Script.pm \
    ./usr/share/perl/5.28.1/Locale/Script.pod \
    ./usr/share/perl/5.28.1/Math/BigFloat.pm \
    ./usr/share/perl/5.28.1/Math/BigFloat/Trace.pm \
    ./usr/share/perl/5.28.1/Math/BigInt.pm \
    ./usr/share/perl/5.28.1/Math/BigInt/Calc.pm \
    ./usr/share/perl/5.28.1/Math/BigInt/CalcEmu.pm \
    ./usr/share/perl/5.28.1/Math/BigInt/Lib.pm \
    ./usr/share/perl/5.28.1/Math/BigInt/Trace.pm \
    ./usr/share/perl/5.28.1/Math/BigRat.pm \
    ./usr/share/perl/5.28.1/Math/Complex.pm \
    ./usr/share/perl/5.28.1/Math/Trig.pm \
    ./usr/share/perl/5.28.1/Memoize.pm \
    ./usr/share/perl/5.28.1/Memoize/AnyDBM_File.pm \
    ./usr/share/perl/5.28.1/Memoize/Expire.pm \
    ./usr/share/perl/5.28.1/Memoize/ExpireFile.pm \
    ./usr/share/perl/5.28.1/Memoize/ExpireTest.pm \
    ./usr/share/perl/5.28.1/Memoize/NDBM_File.pm \
    ./usr/share/perl/5.28.1/Memoize/SDBM_File.pm \
    ./usr/share/perl/5.28.1/Memoize/Storable.pm \
    ./usr/share/perl/5.28.1/Module/CoreList.pm \
    ./usr/share/perl/5.28.1/Module/CoreList.pod \
    ./usr/share/perl/5.28.1/Module/CoreList/Utils.pm \
    ./usr/share/perl/5.28.1/Module/Load.pm \
    ./usr/share/perl/5.28.1/Module/Load/Conditional.pm \
    ./usr/share/perl/5.28.1/Module/Loaded.pm \
    ./usr/share/perl/5.28.1/Module/Metadata.pm \
    ./usr/share/perl/5.28.1/NEXT.pm \
    ./usr/share/perl/5.28.1/Net/Cmd.pm \
    ./usr/share/perl/5.28.1/Net/Config.pm \
    ./usr/share/perl/5.28.1/Net/Domain.pm \
    ./usr/share/perl/5.28.1/Net/FTP.pm \
    ./usr/share/perl/5.28.1/Net/FTP/A.pm \
    ./usr/share/perl/5.28.1/Net/FTP/E.pm \
    ./usr/share/perl/5.28.1/Net/FTP/I.pm \
    ./usr/share/perl/5.28.1/Net/FTP/L.pm \
    ./usr/share/perl/5.28.1/Net/FTP/dataconn.pm \
    ./usr/share/perl/5.28.1/Net/NNTP.pm \
    ./usr/share/perl/5.28.1/Net/Netrc.pm \
    ./usr/share/perl/5.28.1/Net/POP3.pm \
    ./usr/share/perl/5.28.1/Net/Ping.pm \
    ./usr/share/perl/5.28.1/Net/SMTP.pm \
    ./usr/share/perl/5.28.1/Net/Time.pm \
    ./usr/share/perl/5.28.1/Net/hostent.pm \
    ./usr/share/perl/5.28.1/Net/libnetFAQ.pod \
    ./usr/share/perl/5.28.1/Net/netent.pm \
    ./usr/share/perl/5.28.1/Net/protoent.pm \
    ./usr/share/perl/5.28.1/Net/servent.pm \
    ./usr/share/perl/5.28.1/Params/Check.pm \
    ./usr/share/perl/5.28.1/Parse/CPAN/Meta.pm \
    ./usr/share/perl/5.28.1/Perl/OSType.pm \
    ./usr/share/perl/5.28.1/PerlIO.pm \
    ./usr/share/perl/5.28.1/PerlIO/via/QuotedPrint.pm \
    ./usr/share/perl/5.28.1/Pod/Checker.pm \
    ./usr/share/perl/5.28.1/Pod/Escapes.pm \
    ./usr/share/perl/5.28.1/Pod/Find.pm \
    ./usr/share/perl/5.28.1/Pod/Functions.pm \
    ./usr/share/perl/5.28.1/Pod/Html.pm \
    ./usr/share/perl/5.28.1/Pod/InputObjects.pm \
    ./usr/share/perl/5.28.1/Pod/Man.pm \
    ./usr/share/perl/5.28.1/Pod/ParseLink.pm \
    ./usr/share/perl/5.28.1/Pod/ParseUtils.pm \
    ./usr/share/perl/5.28.1/Pod/Parser.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/BaseTo.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/GetOptsOO.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToANSI.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToChecker.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToMan.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToNroff.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToPod.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToRtf.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToTerm.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToText.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToTk.pm \
    ./usr/share/perl/5.28.1/Pod/Perldoc/ToXml.pm \
    ./usr/share/perl/5.28.1/Pod/PlainText.pm \
    ./usr/share/perl/5.28.1/Pod/Select.pm \
    ./usr/share/perl/5.28.1/Pod/Simple.pm \
    ./usr/share/perl/5.28.1/Pod/Simple.pod \
    ./usr/share/perl/5.28.1/Pod/Simple/BlackBox.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/Checker.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/Debug.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/DumpAsText.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/DumpAsXML.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/HTML.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/HTMLBatch.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/HTMLLegacy.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/LinkSection.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/Methody.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/Progress.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/PullParser.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/PullParserEndToken.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/PullParserStartToken.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/PullParserTextToken.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/PullParserToken.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/RTF.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/Search.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/SimpleTree.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/Subclassing.pod \
    ./usr/share/perl/5.28.1/Pod/Simple/Text.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/TextContent.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/TiedOutFH.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/Transcode.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/TranscodeDumb.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/TranscodeSmart.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/XHTML.pm \
    ./usr/share/perl/5.28.1/Pod/Simple/XMLOutStream.pm \
    ./usr/share/perl/5.28.1/Pod/Text.pm \
    ./usr/share/perl/5.28.1/Pod/Text/Color.pm \
    ./usr/share/perl/5.28.1/Pod/Text/Overstrike.pm \
    ./usr/share/perl/5.28.1/Pod/Text/Termcap.pm \
    ./usr/share/perl/5.28.1/Pod/Usage.pm \
    ./usr/share/perl/5.28.1/Safe.pm \
    ./usr/share/perl/5.28.1/Search/Dict.pm \
    ./usr/share/perl/5.28.1/SelectSaver.pm \
    ./usr/share/perl/5.28.1/SelfLoader.pm \
    ./usr/share/perl/5.28.1/Symbol.pm \
    ./usr/share/perl/5.28.1/TAP/Base.pm \
    ./usr/share/perl/5.28.1/TAP/Formatter/Base.pm \
    ./usr/share/perl/5.28.1/TAP/Formatter/Color.pm \
    ./usr/share/perl/5.28.1/TAP/Formatter/Console.pm \
    ./usr/share/perl/5.28.1/TAP/Formatter/Console/ParallelSession.pm \
    ./usr/share/perl/5.28.1/TAP/Formatter/Console/Session.pm \
    ./usr/share/perl/5.28.1/TAP/Formatter/File.pm \
    ./usr/share/perl/5.28.1/TAP/Formatter/File/Session.pm \
    ./usr/share/perl/5.28.1/TAP/Formatter/Session.pm \
    ./usr/share/perl/5.28.1/TAP/Harness.pm \
    ./usr/share/perl/5.28.1/TAP/Harness/Beyond.pod \
    ./usr/share/perl/5.28.1/TAP/Harness/Env.pm \
    ./usr/share/perl/5.28.1/TAP/Object.pm \
    ./usr/share/perl/5.28.1/TAP/Parser.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Aggregator.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Grammar.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Iterator.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Iterator/Array.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Iterator/Process.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Iterator/Stream.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/IteratorFactory.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Multiplexer.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result/Bailout.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result/Comment.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result/Plan.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result/Pragma.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result/Test.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result/Unknown.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result/Version.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Result/YAML.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/ResultFactory.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Scheduler.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Scheduler/Job.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Scheduler/Spinner.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/Source.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/SourceHandler.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/SourceHandler/Executable.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/SourceHandler/File.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/SourceHandler/Handle.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/SourceHandler/Perl.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/SourceHandler/RawTAP.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/YAMLish/Reader.pm \
    ./usr/share/perl/5.28.1/TAP/Parser/YAMLish/Writer.pm \
    ./usr/share/perl/5.28.1/Term/ANSIColor.pm \
    ./usr/share/perl/5.28.1/Term/Cap.pm \
    ./usr/share/perl/5.28.1/Term/Complete.pm \
    ./usr/share/perl/5.28.1/Term/ReadLine.pm \
    ./usr/share/perl/5.28.1/Test.pm \
    ./usr/share/perl/5.28.1/Test/Builder.pm \
    ./usr/share/perl/5.28.1/Test/Builder/Formatter.pm \
    ./usr/share/perl/5.28.1/Test/Builder/IO/Scalar.pm \
    ./usr/share/perl/5.28.1/Test/Builder/Module.pm \
    ./usr/share/perl/5.28.1/Test/Builder/Tester.pm \
    ./usr/share/perl/5.28.1/Test/Builder/Tester/Color.pm \
    ./usr/share/perl/5.28.1/Test/Builder/TodoDiag.pm \
    ./usr/share/perl/5.28.1/Test/Harness.pm \
    ./usr/share/perl/5.28.1/Test/More.pm \
    ./usr/share/perl/5.28.1/Test/Simple.pm \
    ./usr/share/perl/5.28.1/Test/Tester.pm \
    ./usr/share/perl/5.28.1/Test/Tester/Capture.pm \
    ./usr/share/perl/5.28.1/Test/Tester/CaptureRunner.pm \
    ./usr/share/perl/5.28.1/Test/Tester/Delegate.pm \
    ./usr/share/perl/5.28.1/Test/Tutorial.pod \
    ./usr/share/perl/5.28.1/Test/use/ok.pm \
    ./usr/share/perl/5.28.1/Test2.pm \
    ./usr/share/perl/5.28.1/Test2/API.pm \
    ./usr/share/perl/5.28.1/Test2/API/Breakage.pm \
    ./usr/share/perl/5.28.1/Test2/API/Context.pm \
    ./usr/share/perl/5.28.1/Test2/API/Instance.pm \
    ./usr/share/perl/5.28.1/Test2/API/Stack.pm \
    ./usr/share/perl/5.28.1/Test2/Event.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Bail.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Diag.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Encoding.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Exception.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Fail.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Generic.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Note.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Ok.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Pass.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Plan.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Skip.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Subtest.pm \
    ./usr/share/perl/5.28.1/Test2/Event/TAP/Version.pm \
    ./usr/share/perl/5.28.1/Test2/Event/V2.pm \
    ./usr/share/perl/5.28.1/Test2/Event/Waiting.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/About.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Amnesty.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Assert.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Control.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Error.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Hub.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Info.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Meta.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Parent.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Plan.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Render.pm \
    ./usr/share/perl/5.28.1/Test2/EventFacet/Trace.pm \
    ./usr/share/perl/5.28.1/Test2/Formatter.pm \
    ./usr/share/perl/5.28.1/Test2/Formatter/TAP.pm \
    ./usr/share/perl/5.28.1/Test2/Hub.pm \
    ./usr/share/perl/5.28.1/Test2/Hub/Interceptor.pm \
    ./usr/share/perl/5.28.1/Test2/Hub/Interceptor/Terminator.pm \
    ./usr/share/perl/5.28.1/Test2/Hub/Subtest.pm \
    ./usr/share/perl/5.28.1/Test2/IPC.pm \
    ./usr/share/perl/5.28.1/Test2/IPC/Driver.pm \
    ./usr/share/perl/5.28.1/Test2/IPC/Driver/Files.pm \
    ./usr/share/perl/5.28.1/Test2/Tools/Tiny.pm \
    ./usr/share/perl/5.28.1/Test2/Transition.pod \
    ./usr/share/perl/5.28.1/Test2/Util.pm \
    ./usr/share/perl/5.28.1/Test2/Util/ExternalMeta.pm \
    ./usr/share/perl/5.28.1/Test2/Util/Facets2Legacy.pm \
    ./usr/share/perl/5.28.1/Test2/Util/HashBase.pm \
    ./usr/share/perl/5.28.1/Test2/Util/Trace.pm \
    ./usr/share/perl/5.28.1/Text/Abbrev.pm \
    ./usr/share/perl/5.28.1/Text/Balanced.pm \
    ./usr/share/perl/5.28.1/Text/ParseWords.pm \
    ./usr/share/perl/5.28.1/Text/Tabs.pm \
    ./usr/share/perl/5.28.1/Text/Wrap.pm \
    ./usr/share/perl/5.28.1/Thread.pm \
    ./usr/share/perl/5.28.1/Thread/Queue.pm \
    ./usr/share/perl/5.28.1/Thread/Semaphore.pm \
    ./usr/share/perl/5.28.1/Tie/Array.pm \
    ./usr/share/perl/5.28.1/Tie/File.pm \
    ./usr/share/perl/5.28.1/Tie/Handle.pm \
    ./usr/share/perl/5.28.1/Tie/Hash.pm \
    ./usr/share/perl/5.28.1/Tie/Memoize.pm \
    ./usr/share/perl/5.28.1/Tie/RefHash.pm \
    ./usr/share/perl/5.28.1/Tie/Scalar.pm \
    ./usr/share/perl/5.28.1/Tie/StdHandle.pm \
    ./usr/share/perl/5.28.1/Tie/SubstrHash.pm \
    ./usr/share/perl/5.28.1/Time/Local.pm \
    ./usr/share/perl/5.28.1/Time/gmtime.pm \
    ./usr/share/perl/5.28.1/Time/localtime.pm \
    ./usr/share/perl/5.28.1/Time/tm.pm \
    ./usr/share/perl/5.28.1/UNIVERSAL.pm \
    ./usr/share/perl/5.28.1/Unicode/Collate/CJK/Big5.pm \
    ./usr/share/perl/5.28.1/Unicode/Collate/CJK/GB2312.pm \
    ./usr/share/perl/5.28.1/Unicode/Collate/CJK/JISX0208.pm \
    ./usr/share/perl/5.28.1/Unicode/Collate/CJK/Korean.pm \
    ./usr/share/perl/5.28.1/Unicode/Collate/CJK/Pinyin.pm \
    ./usr/share/perl/5.28.1/Unicode/Collate/CJK/Stroke.pm \
    ./usr/share/perl/5.28.1/Unicode/Collate/CJK/Zhuyin.pm \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/af.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ar.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/as.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/az.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/be.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/bn.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ca.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/cs.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/cy.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/da.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/de_at_ph.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/de_phone.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/dsb.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ee.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/eo.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/es.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/es_trad.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/et.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/fa.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/fi.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/fi_phone.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/fil.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/fo.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/fr_ca.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/gu.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ha.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/haw.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/he.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/hi.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/hr.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/hu.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/hy.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ig.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/is.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ja.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/kk.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/kl.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/kn.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ko.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/kok.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/lkt.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ln.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/lt.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/lv.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/mk.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ml.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/mr.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/mt.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/nb.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/nn.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/nso.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/om.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/or.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/pa.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/pl.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ro.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/sa.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/se.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/si.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/si_dict.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/sk.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/sl.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/sq.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/sr.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/sv.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/sv_refo.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ta.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/te.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/th.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/tn.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/to.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/tr.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ug_cyrl.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/uk.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/ur.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/vi.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/vo.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/wae.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/wo.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/yo.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/zh.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/zh_big5.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/zh_gb.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/zh_pin.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/zh_strk.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/Locale/zh_zhu.pl \
    ./usr/share/perl/5.28.1/Unicode/Collate/allkeys.txt \
    ./usr/share/perl/5.28.1/Unicode/Collate/keys.txt \
    ./usr/share/perl/5.28.1/Unicode/UCD.pm \
    ./usr/share/perl/5.28.1/User/grent.pm \
    ./usr/share/perl/5.28.1/User/pwent.pm \
    ./usr/share/perl/5.28.1/XSLoader.pm \
    ./usr/share/perl/5.28.1/_charnames.pm \
    ./usr/share/perl/5.28.1/autodie.pm \
    ./usr/share/perl/5.28.1/autodie/Scope/Guard.pm \
    ./usr/share/perl/5.28.1/autodie/Scope/GuardStack.pm \
    ./usr/share/perl/5.28.1/autodie/Util.pm \
    ./usr/share/perl/5.28.1/autodie/exception.pm \
    ./usr/share/perl/5.28.1/autodie/exception/system.pm \
    ./usr/share/perl/5.28.1/autodie/hints.pm \
    ./usr/share/perl/5.28.1/autodie/skip.pm \
    ./usr/share/perl/5.28.1/autouse.pm \
    ./usr/share/perl/5.28.1/base.pm \
    ./usr/share/perl/5.28.1/bigint.pm \
    ./usr/share/perl/5.28.1/bignum.pm \
    ./usr/share/perl/5.28.1/bigrat.pm \
    ./usr/share/perl/5.28.1/blib.pm \
    ./usr/share/perl/5.28.1/bytes.pm \
    ./usr/share/perl/5.28.1/bytes_heavy.pl \
    ./usr/share/perl/5.28.1/charnames.pm \
    ./usr/share/perl/5.28.1/constant.pm \
    ./usr/share/perl/5.28.1/deprecate.pm \
    ./usr/share/perl/5.28.1/diagnostics.pm \
    ./usr/share/perl/5.28.1/dumpvar.pl \
    ./usr/share/perl/5.28.1/encoding/warnings.pm \
    ./usr/share/perl/5.28.1/experimental.pm \
    ./usr/share/perl/5.28.1/feature.pm \
    ./usr/share/perl/5.28.1/fields.pm \
    ./usr/share/perl/5.28.1/filetest.pm \
    ./usr/share/perl/5.28.1/if.pm \
    ./usr/share/perl/5.28.1/integer.pm \
    ./usr/share/perl/5.28.1/less.pm \
    ./usr/share/perl/5.28.1/locale.pm \
    ./usr/share/perl/5.28.1/meta_notation.pm \
    ./usr/share/perl/5.28.1/ok.pm \
    ./usr/share/perl/5.28.1/open.pm \
    ./usr/share/perl/5.28.1/overload.pm \
    ./usr/share/perl/5.28.1/overload/numbers.pm \
    ./usr/share/perl/5.28.1/overloading.pm \
    ./usr/share/perl/5.28.1/parent.pm \
    ./usr/share/perl/5.28.1/perl5db.pl \
    ./usr/share/perl/5.28.1/perlfaq.pm \
    ./usr/share/perl/5.28.1/pod/perldiag.pod \
    ./usr/share/perl/5.28.1/sigtrap.pm \
    ./usr/share/perl/5.28.1/sort.pm \
    ./usr/share/perl/5.28.1/strict.pm \
    ./usr/share/perl/5.28.1/subs.pm \
    ./usr/share/perl/5.28.1/unicore/Blocks.txt \
    ./usr/share/perl/5.28.1/unicore/CombiningClass.pl \
    ./usr/share/perl/5.28.1/unicore/Decomposition.pl \
    ./usr/share/perl/5.28.1/unicore/Heavy.pl \
    ./usr/share/perl/5.28.1/unicore/Name.pl \
    ./usr/share/perl/5.28.1/unicore/Name.pm \
    ./usr/share/perl/5.28.1/unicore/NamedSequences.txt \
    ./usr/share/perl/5.28.1/unicore/SpecialCasing.txt \
    ./usr/share/perl/5.28.1/unicore/To/Age.pl \
    ./usr/share/perl/5.28.1/unicore/To/Bc.pl \
    ./usr/share/perl/5.28.1/unicore/To/Bmg.pl \
    ./usr/share/perl/5.28.1/unicore/To/Bpb.pl \
    ./usr/share/perl/5.28.1/unicore/To/Bpt.pl \
    ./usr/share/perl/5.28.1/unicore/To/Cf.pl \
    ./usr/share/perl/5.28.1/unicore/To/Digit.pl \
    ./usr/share/perl/5.28.1/unicore/To/Ea.pl \
    ./usr/share/perl/5.28.1/unicore/To/Fold.pl \
    ./usr/share/perl/5.28.1/unicore/To/GCB.pl \
    ./usr/share/perl/5.28.1/unicore/To/Gc.pl \
    ./usr/share/perl/5.28.1/unicore/To/Hst.pl \
    ./usr/share/perl/5.28.1/unicore/To/InPC.pl \
    ./usr/share/perl/5.28.1/unicore/To/InSC.pl \
    ./usr/share/perl/5.28.1/unicore/To/Isc.pl \
    ./usr/share/perl/5.28.1/unicore/To/Jg.pl \
    ./usr/share/perl/5.28.1/unicore/To/Jt.pl \
    ./usr/share/perl/5.28.1/unicore/To/Lb.pl \
    ./usr/share/perl/5.28.1/unicore/To/Lc.pl \
    ./usr/share/perl/5.28.1/unicore/To/Lower.pl \
    ./usr/share/perl/5.28.1/unicore/To/NFCQC.pl \
    ./usr/share/perl/5.28.1/unicore/To/NFDQC.pl \
    ./usr/share/perl/5.28.1/unicore/To/NFKCCF.pl \
    ./usr/share/perl/5.28.1/unicore/To/NFKCQC.pl \
    ./usr/share/perl/5.28.1/unicore/To/NFKDQC.pl \
    ./usr/share/perl/5.28.1/unicore/To/Na1.pl \
    ./usr/share/perl/5.28.1/unicore/To/NameAlia.pl \
    ./usr/share/perl/5.28.1/unicore/To/Nt.pl \
    ./usr/share/perl/5.28.1/unicore/To/Nv.pl \
    ./usr/share/perl/5.28.1/unicore/To/PerlDeci.pl \
    ./usr/share/perl/5.28.1/unicore/To/SB.pl \
    ./usr/share/perl/5.28.1/unicore/To/Sc.pl \
    ./usr/share/perl/5.28.1/unicore/To/Scx.pl \
    ./usr/share/perl/5.28.1/unicore/To/Tc.pl \
    ./usr/share/perl/5.28.1/unicore/To/Title.pl \
    ./usr/share/perl/5.28.1/unicore/To/Uc.pl \
    ./usr/share/perl/5.28.1/unicore/To/Upper.pl \
    ./usr/share/perl/5.28.1/unicore/To/Vo.pl \
    ./usr/share/perl/5.28.1/unicore/To/WB.pl \
    ./usr/share/perl/5.28.1/unicore/To/_PerlLB.pl \
    ./usr/share/perl/5.28.1/unicore/To/_PerlSCX.pl \
    ./usr/share/perl/5.28.1/unicore/To/_PerlWB.pl \
    ./usr/share/perl/5.28.1/unicore/UCD.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/NA.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V100.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V11.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V20.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V30.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V31.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V32.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V40.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V41.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V50.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V51.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V52.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V60.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V61.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V70.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V80.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Age/V90.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Alpha/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/AL.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/AN.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/B.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/BN.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/CS.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/EN.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/ES.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/ET.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/L.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/NSM.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/ON.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/R.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bc/WS.pl \
    ./usr/share/perl/5.28.1/unicore/lib/BidiC/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/BidiM/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Blk/NB.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bpt/C.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bpt/N.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Bpt/O.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CE/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CI/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CWCF/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CWCM/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CWKCF/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CWL/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CWT/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CWU/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Cased/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/A.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/AL.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/AR.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/ATAR.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/B.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/BR.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/DB.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/NK.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/NR.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/OV.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ccc/VR.pl \
    ./usr/share/perl/5.28.1/unicore/lib/CompEx/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/DI/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dash/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dep/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dia/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Com.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Enc.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Fin.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Font.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Init.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Iso.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Med.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Nar.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Nb.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/NonCanon.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Sqr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Sub.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Sup.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Dt/Vert.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ea/A.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ea/H.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ea/N.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ea/Na.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ea/W.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ext/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/CN.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/EB.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/EX.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/GAZ.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/LV.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/LVT.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/PP.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/SM.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GCB/XX.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/C.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Cf.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Cn.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/L.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/LC.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Ll.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Lm.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Lo.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Lu.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/M.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Mc.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Me.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Mn.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/N.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Nd.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Nl.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/No.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/P.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Pc.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Pd.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Pe.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Pf.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Pi.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Po.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Ps.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/S.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Sc.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Sk.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Sm.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/So.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Z.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Gc/Zs.pl \
    ./usr/share/perl/5.28.1/unicore/lib/GrBase/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Hex/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Hst/NA.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Hyphen/T.pl \
    ./usr/share/perl/5.28.1/unicore/lib/IDC/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/IDS/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Ideo/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/10_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/2_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/2_1.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/3_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/3_1.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/3_2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/4_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/4_1.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/5_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/5_1.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/5_2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/6_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/6_1.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/6_2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/6_3.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/7_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/8_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/In/9_0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/Bottom.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/Left.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/LeftAndR.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/NA.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/Overstru.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/Right.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/Top.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/TopAndBo.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/TopAndL2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/TopAndLe.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/TopAndRi.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InPC/VisualOr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Avagraha.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Bindu.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Cantilla.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Consona2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Consona3.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Consona4.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Consona5.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Consona6.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Consonan.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Invisibl.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Nukta.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Number.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Other.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/PureKill.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Syllable.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/ToneMark.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Virama.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Visarga.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/Vowel.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/VowelDep.pl \
    ./usr/share/perl/5.28.1/unicore/lib/InSC/VowelInd.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Ain.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Alef.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Beh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Dal.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/FarsiYeh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Feh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Gaf.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Hah.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Kaf.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Lam.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/NoJoinin.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Qaf.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Reh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Sad.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Seen.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Waw.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jg/Yeh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jt/C.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jt/D.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jt/R.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jt/T.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Jt/U.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/AI.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/AL.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/BA.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/BB.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/CJ.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/CL.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/CM.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/EB.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/EX.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/GL.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/ID.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/IN.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/IS.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/NS.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/OP.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/PO.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/PR.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/QU.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/SA.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lb/XX.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Lower/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Math/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/NFCQC/M.pl \
    ./usr/share/perl/5.28.1/unicore/lib/NFCQC/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/NFDQC/N.pl \
    ./usr/share/perl/5.28.1/unicore/lib/NFDQC/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/NFKCQC/N.pl \
    ./usr/share/perl/5.28.1/unicore/lib/NFKCQC/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/NFKDQC/N.pl \
    ./usr/share/perl/5.28.1/unicore/lib/NFKDQC/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nt/Di.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nt/None.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nt/Nu.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/0.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/1.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/10.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/100.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/1000.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/10000.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/11.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/12.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/13.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/14.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/15.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/16.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/17.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/18.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/19.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/1_16.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/1_2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/1_3.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/1_4.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/1_8.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/20.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/200.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/2_3.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/3.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/30.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/300.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/3_16.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/3_4.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/4.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/40.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/400.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/5.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/50.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/500.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/5000.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/50000.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/6.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/60.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/600.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/7.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/70.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/700.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/8.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/80.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/800.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/9.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/90.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Nv/900.pl \
    ./usr/share/perl/5.28.1/unicore/lib/PCM/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/PatSyn/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/Alnum.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/Assigned.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/Blank.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/Graph.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/PerlWord.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/PosixPun.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/Print.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/SpacePer.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/Title.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/Word.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/XPosixPu.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlAny.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlCh2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlCha.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlFol.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlIDC.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlIDS.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlNch.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlPat.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlPr2.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlPro.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Perl/_PerlQuo.pl \
    ./usr/share/perl/5.28.1/unicore/lib/QMark/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/AT.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/CL.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/EX.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/FO.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/LE.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/LO.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/NU.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/SC.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/ST.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/Sp.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/UP.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SB/XX.pl \
    ./usr/share/perl/5.28.1/unicore/lib/SD/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/STerm/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Arab.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Armn.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Beng.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Cprt.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Cyrl.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Deva.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Dupl.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Geor.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Glag.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Gran.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Grek.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Gujr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Guru.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Han.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Hang.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Hira.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Kana.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Knda.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Latn.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Limb.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Linb.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Mlym.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Mong.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Mult.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Orya.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Sinh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Syrc.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Taml.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Telu.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Zinh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Sc/Zyyy.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Adlm.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Arab.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Armn.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Beng.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Bhks.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Bopo.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Cakm.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Cham.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Copt.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Cprt.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Cyrl.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Deva.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Dupl.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Ethi.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Geor.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Glag.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Gonm.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Gran.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Grek.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Gujr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Guru.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Han.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Hang.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Hebr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Hira.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Hmng.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Kana.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Khar.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Khmr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Knda.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Lana.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Lao.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Latn.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Limb.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Lina.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Linb.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Mlym.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Mong.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Mult.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Mymr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Orya.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Phlp.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Shrd.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Sind.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Sinh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Syrc.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Tagb.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Takr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Talu.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Taml.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Telu.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Thaa.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Tibt.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Tirh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Xsux.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Yi.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Zinh.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Zyyy.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Scx/Zzzz.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Term/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/UIdeo/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Upper/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Vo/R.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Vo/Tr.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Vo/Tu.pl \
    ./usr/share/perl/5.28.1/unicore/lib/Vo/U.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/EX.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/Extend.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/FO.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/HL.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/KA.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/LE.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/MB.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/ML.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/MN.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/NU.pl \
    ./usr/share/perl/5.28.1/unicore/lib/WB/XX.pl \
    ./usr/share/perl/5.28.1/unicore/lib/XIDC/Y.pl \
    ./usr/share/perl/5.28.1/unicore/lib/XIDS/Y.pl \
    ./usr/share/perl/5.28.1/unicore/version \
    ./usr/share/perl/5.28.1/utf8.pm \
    ./usr/share/perl/5.28.1/utf8_heavy.pl \
    ./usr/share/perl/5.28.1/vars.pm \
    ./usr/share/perl/5.28.1/version.pm \
    ./usr/share/perl/5.28.1/version.pod \
    ./usr/share/perl/5.28.1/version/Internals.pod \
    ./usr/share/perl/5.28.1/version/regex.pm \
    ./usr/share/perl/5.28.1/vmsish.pm \
    ./usr/share/perl/5.28.1/warnings.pm \
    ./usr/share/perl/5.28.1/warnings/register.pm\
"
