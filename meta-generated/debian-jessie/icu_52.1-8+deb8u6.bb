PACKAGES = "${PN} icu-devtools libicu-dev libicu52"
PROVIDES = "icu-devtools libicu-dev libicu52"
SRC_URI = " \
	http://ftp.de.debian.org/debian/pool/main/i/icu/icu-devtools_52.1-8+deb8u6_armhf.deb;unpack=0;name=deb0\
	http://ftp.de.debian.org/debian/pool/main/i/icu/libicu-dev_52.1-8+deb8u6_armhf.deb;unpack=0;name=deb1\
	http://ftp.de.debian.org/debian/pool/main/i/icu/libicu52_52.1-8+deb8u6_armhf.deb;unpack=0;name=deb2\
"
DEBFILENAME_icu-devtools = "icu-devtools_52.1-8+deb8u6_armhf.deb"
SRC_URI[deb0.sha256sum] = "8a0eac495b7718869491b97f40cdc60dbab8eeee86e222cbb9e95a2908bd949e"
SRC_URI[deb0.md5sum] = "50209e29180305500730e7f153b72c8f"
DEBFILENAME_libicu-dev = "libicu-dev_52.1-8+deb8u6_armhf.deb"
SRC_URI[deb1.sha256sum] = "1defe6edd1185acd2b15f0ba41707a03de62cf207d981565bed3d18070d05a10"
SRC_URI[deb1.md5sum] = "95f7498378412432825f67f2d9c0f920"
DEBFILENAME_libicu52 = "libicu52_52.1-8+deb8u6_armhf.deb"
SRC_URI[deb2.sha256sum] = "fe3e6aa80e0ea34667c22b63e9f86b1c1481d44b4ae9e0ee759254480a0cb289"
SRC_URI[deb2.md5sum] = "b10657204fed39e062771241d76717fa"

RDEPENDS_${PN}-devtools = "libc6 (>= 2.4) libgcc1 (>= 1:4.4.0) libicu52 (>= 52~m1-1~) libstdc++6 (>= 4.9)"
RDEPENDS_lib${PN}-dev = "libicu52 (= 52.1-8+deb8u6) icu-devtools (>= 52.1-8+deb8u6) libc6-dev"
RDEPENDS_lib${PN}52 = "libc6 (>= 2.7) libgcc1 (>= 1:4.4.0) libstdc++6 (>= 4.9)"
DEPENDS = "libgcc1 libstdc++6 libc6-dev libc6"


inherit deb_group

# Prebuilt binaries, no need for any default dependencies
INHIBIT_DEFAULT_DEPS = "1"
INHIBIT_PACKAGE_STRIP = "1"
INSANE_SKIP_${PN} += "already-stripped"

FILES_icu-devtools = " \
    ./usr/sbin/gencmn \
    ./usr/bin/gencfu \
    ./usr/share/man/man1/pkgdata.1.gz \
    ./usr/share/man/man8/gensprep.8.gz \
    ./usr/share/man/man8/gennorm2.8.gz \
    ./usr/bin/gendict \
    ./usr/share/man/man1/gencnval.1.gz \
    ./usr/share/man/man1/gendict.1.gz \
    ./usr/share/man/man1/makeconv.1.gz \
    ./usr/share/man/man1/icu-config.1.gz \
    ./usr/sbin/gensprep \
    ./usr/share/man/man1/genbrk.1.gz \
    ./usr/share/doc/icu-devtools/copyright \
    ./usr/share/doc/icu-devtools/changelog.Debian.gz \
    ./usr/sbin/gennorm2 \
    ./usr/bin/derb \
    ./usr/bin/icuinfo \
    ./usr/share/man/man8/gencmn.8.gz \
    ./usr/share/man/man1/gencfu.1.gz \
    ./usr/bin/pkgdata \
    ./usr/bin/genbrk \
    ./usr/bin/uconv \
    ./usr/bin/gencnval \
    ./usr/share/man/man8/icupkg.8.gz \
    ./usr/sbin/genccode \
    ./usr/sbin/icupkg \
    ./usr/bin/makeconv \
    ./usr/share/man/man1/uconv.1.gz \
    ./usr/share/man/man1/derb.1.gz \
    ./usr/share/man/man8/genccode.8.gz \
    ./usr/share/man/man1/genrb.1.gz \
    ./usr/bin/icu-config \
    ./usr/share/doc/icu-devtools/NEWS.Debian.gz \
    ./usr/bin/genrb \
    ./usr/share/man/man1/icuinfo.1.gz\
"
FILES_libicu-dev = " \
    ./usr/share/doc/libicu-dev/examples/uciter8/readme.txt \
    ./usr/share/doc/libicu-dev/examples/layout/Sample.txt \
    ./usr/include/arm-linux-gnueabihf/layout/playout.h \
    ./usr/share/doc/libicu-dev/examples/ustring/ustring.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/ucnv/readme.txt \
    ./usr/lib/arm-linux-gnueabihf/icu/52.1/pkgdata.inc \
    ./usr/include/arm-linux-gnueabihf/unicode/coleitr.h \
    ./usr/include/arm-linux-gnueabihf/unicode/fieldpos.h \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-le.pc \
    ./usr/share/doc/libicu-dev/examples/layout/ScriptCompositeFontInstance.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucurr.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/ugrep.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/icuplug.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/util.h \
    ./usr/share/icu/52.1/mkinstalldirs \
    ./usr/include/arm-linux-gnueabihf/unicode/uformattable.h \
    ./usr/share/doc/libicu-dev/examples/dtptngsample/dtptngsample.vcxproj.filters \
    ./usr/share/doc/libicu-dev/copyright \
    ./usr/include/arm-linux-gnueabihf/unicode/decimfmt.h \
    ./usr/share/doc/libicu-dev/examples/translit/answers/unaccent.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/uniset.h \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-uc.pc \
    ./usr/lib/arm-linux-gnueabihf/libicutu.so \
    ./usr/include/arm-linux-gnueabihf/unicode/ucat.h \
    ./usr/include/arm-linux-gnueabihf/unicode/timezone.h \
    ./usr/share/doc/libicu-dev/examples/case/case.sln \
    ./usr/share/doc/libicu-dev/examples/uciter8/uciter8.sln \
    ./usr/include/arm-linux-gnueabihf/layout/loengine.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/data02.bin \
    ./usr/include/arm-linux-gnueabihf/unicode/idna.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tblcoll.h \
    ./usr/include/arm-linux-gnueabihf/unicode/dtptngen.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucoleitr.h \
    ./usr/include/arm-linux-gnueabihf/unicode/usearch.h \
    ./usr/share/doc/libicu-dev/examples/break/ubreak.c \
    ./usr/share/doc/libicu-dev/examples/date/uprint.c \
    ./usr/share/doc/libicu-dev/examples/date/date.c \
    ./usr/share/doc/libicu-dev/examples/numfmt/numfmt.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/normalizer2.h \
    ./usr/share/doc/libicu-dev/examples/layout/clayout.c \
    ./usr/include/arm-linux-gnueabihf/unicode/tztrans.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/flagcb.c \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/udisplaycontext.h \
    ./usr/include/arm-linux-gnueabihf/unicode/fpositer.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ugender.h \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeFontInstance.h \
    ./usr/share/doc/libicu-dev/examples/uresb/sr.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/listformatter.h \
    ./usr/include/arm-linux-gnueabihf/layout/LEFontInstance.h \
    ./usr/share/doc/libicu-dev/examples/uresb/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/dcfmtsym.h \
    ./usr/lib/arm-linux-gnueabihf/libicudata.a \
    ./usr/share/doc/libicu-dev/examples/udata/writer.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/uconfig.h \
    ./usr/share/doc/libicu-dev/examples/layout/layout.sln \
    ./usr/share/doc/libicu-dev/examples/legacy/legacy.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/ustringtrie.h \
    ./usr/include/arm-linux-gnueabihf/unicode/smpdtfmt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utrace.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ures.h \
    ./usr/share/doc/libicu-dev/examples/translit/translit.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/layout/GDIFontMap.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/dtitvinf.h \
    ./usr/share/doc/libicu-dev/examples/datecal/ccal.c \
    ./usr/share/doc/libicu-dev/examples/layout/resource.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/main.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/alphaindex.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/msgfmt.vcxproj \
    ./usr/share/doc/libicu-dev/examples/defs.mk \
    ./usr/share/doc/libicu-dev/examples/date/Makefile.in \
    ./usr/share/doc/libicu-dev/examples/translit/util.cpp \
    ./usr/share/doc/libicu-dev/examples/uresb/en.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/uchar.h \
    ./usr/share/doc/libicu-dev/examples/layout/pflow.c \
    ./usr/share/doc/libicu-dev/examples/layout/layout.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/format.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucal.h \
    ./usr/share/doc/libicu-dev/examples/ufortune/Makefile \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeGUISupport.h \
    ./usr/include/arm-linux-gnueabihf/unicode/symtable.h \
    ./usr/include/arm-linux-gnueabihf/layout/LayoutEngine.h \
    ./usr/share/doc/libicu-dev/examples/layout/FontMap.cpp \
    ./usr/include/arm-linux-gnueabihf/layout/RunArrays.h \
    ./usr/include/arm-linux-gnueabihf/unicode/udat.h \
    ./usr/share/doc/libicu-dev/examples/layout/cmaps.h \
    ./usr/include/arm-linux-gnueabihf/unicode/region.h \
    ./usr/share/doc/libicu-dev/examples/uciter8/uciter8.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/uregex.h \
    ./usr/share/doc/libicu-dev/examples/numfmt/util.h \
    ./usr/share/doc/libicu-dev/examples/layout/UnicodeReader.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucasemap.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utext.h \
    ./usr/share/doc/libicu-dev/examples/strsrch/readme.txt \
    ./usr/share/doc/libicu-dev/examples/datecal/cal.cpp \
    ./usr/share/doc/libicu-dev/examples/translit/unaccent.cpp \
    ./usr/share/doc/libicu-dev/examples/coll/coll.sln \
    ./usr/share/doc/libicu-dev/examples/ufortune/ufortune.vcxproj \
    ./usr/share/doc/libicu-dev/examples/Makefile.in \
    ./usr/share/doc/libicu-dev/examples/translit/answers/main_1.cpp \
    ./usr/share/doc/libicu-dev/examples/uciter8/uciter8.c \
    ./usr/include/arm-linux-gnueabihf/unicode/measunit.h \
    ./usr/lib/arm-linux-gnueabihf/libicutest.so \
    ./usr/share/doc/libicu-dev/examples/layout/ucreader.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/search.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/README.TXT \
    ./usr/share/doc/libicu-dev/examples/case/Makefile \
    ./usr/share/doc/libicu-dev/examples/uciter8/Makefile \
    ./usr/include/arm-linux-gnueabihf/layout/LELanguages.h \
    ./usr/share/doc/libicu-dev/examples/udata/reader.c \
    ./usr/share/doc/libicu-dev/examples/strsrch/strsrch.cpp \
    ./usr/share/doc/libicu-dev/examples/citer/citer.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/uenum.h \
    ./usr/share/doc/libicu-dev/examples/ustring/ustring.sln \
    ./usr/share/doc/libicu-dev/examples/date/date.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/appendable.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/Makefile \
    ./usr/include/arm-linux-gnueabihf/layout/LEGlyphStorage.h \
    ./usr/include/arm-linux-gnueabihf/unicode/currpinf.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ustdio.h \
    ./usr/share/doc/libicu-dev/examples/layout/Surface.cpp \
    ./usr/share/doc/libicu-dev/examples/udata/udata.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/ucol.h \
    ./usr/include/arm-linux-gnueabihf/unicode/upluralrules.h \
    ./usr/share/doc/libicu-dev/examples/all/all.sln \
    ./usr/share/doc/libicu-dev/examples/ufortune/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/caniter.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/flagcb.h \
    ./usr/include/arm-linux-gnueabihf/unicode/msgfmt.h \
    ./usr/share/doc/libicu-dev/examples/translit/answers/main_3.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/GDIGUISupport.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucsdet.h \
    ./usr/lib/arm-linux-gnueabihf/libicule.so \
    ./usr/share/doc/libicu-dev/examples/ufortune/ufortune.sln \
    ./usr/share/doc/libicu-dev/examples/coll/coll.vcxproj \
    ./usr/share/doc/libicu-dev/examples/translit/translit.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/utf.h \
    ./usr/share/doc/libicu-dev/examples/uresb/resources.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/ucnv/ucnv.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/ucnv/ucnv.vcxproj \
    ./usr/include/arm-linux-gnueabihf/layout/LEScripts.h \
    ./usr/share/doc/libicu-dev/examples/uresb/root.txt \
    ./usr/share/doc/libicu-dev/examples/Makefile \
    ./usr/share/doc/libicu-dev/examples/msgfmt/main.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/brkiter.h \
    ./usr/share/doc/libicu-dev/examples/cal/cal.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/sortkey.h \
    ./usr/share/doc/libicu-dev/examples/layout/RenderingSurface.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/answers/main_0.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/gnomeglue.h \
    ./usr/share/doc/libicu-dev/examples/translit/unaccent.h \
    ./usr/share/doc/libicu-dev/examples/legacy/legacy.vcxproj \
    ./usr/share/doc/libicu-dev/examples/legacy/legacy.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/bytestream.h \
    ./usr/share/doc/libicu-dev/examples/layout/gdiglue.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/Makefile \
    ./usr/share/doc/libicu-dev/examples/udata/reader.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/urep.h \
    ./usr/include/arm-linux-gnueabihf/unicode/rep.h \
    ./usr/share/doc/libicu-dev/NEWS.Debian.gz \
    ./usr/share/doc/libicu-dev/examples/layout/UnicodeReader.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/fmtable.h \
    ./usr/share/doc/libicu-dev/changelog.Debian.gz \
    ./usr/share/doc/libicu-dev/examples/csdet/csdet.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/res-file-list.txt \
    ./usr/share/doc/libicu-dev/examples/udata/reader.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/legacy/legacy.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/paragraph.cpp \
    ./usr/share/doc/libicu-dev/examples/ufortune/ufortune.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/date/Makefile \
    ./usr/share/doc/libicu-dev/examples/layout/gsupport.h \
    ./usr/share/doc/libicu-dev/examples/layout/layout.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/putil.h \
    ./usr/share/doc/libicu-dev/examples/translit/translit.sln \
    ./usr/share/doc/libicu-dev/examples/uresb/resources.mak \
    ./usr/include/arm-linux-gnueabihf/unicode/utypes.h \
    ./usr/share/doc/libicu-dev/examples/layout/GDIFontInstance.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/answers/main_2.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/umisc.h \
    ./usr/share/doc/libicu-dev/examples/props/Makefile \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeFontMap.h \
    ./usr/share/doc/libicu-dev/examples/ufortune/fortunedefs.mk \
    ./usr/share/doc/libicu-dev/examples/numfmt/numfmt.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/layout/LETypes.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uiter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ushape.h \
    ./usr/include/arm-linux-gnueabihf/unicode/compactdecimalformat.h \
    ./usr/share/doc/libicu-dev/examples/props/props.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/uidna.h \
    ./usr/include/arm-linux-gnueabihf/unicode/gender.h \
    ./usr/share/doc/libicu-dev/examples/translit/Makefile \
    ./usr/share/doc/libicu-dev/examples/legacy/oldcol.cpp \
    ./usr/share/doc/libicu-dev/examples/ufortune/ufortune.c \
    ./usr/include/arm-linux-gnueabihf/unicode/uchriter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/strenum.h \
    ./usr/share/doc/libicu-dev/examples/strsrch/strsrch.vcxproj \
    ./usr/share/doc/libicu-dev/examples/udata/Makefile \
    ./usr/share/doc/libicu-dev/examples/layout/pflow.h \
    ./usr/share/doc/libicu-dev/examples/layout/ScriptCompositeFontInstance.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeFontInstance.cpp \
    ./usr/lib/arm-linux-gnueabihf/libicudata.so \
    ./usr/include/arm-linux-gnueabihf/unicode/umachine.h \
    ./usr/share/doc/libicu-dev/examples/layout/rsurface.h \
    ./usr/include/arm-linux-gnueabihf/layout/LEGlyphFilter.h \
    ./usr/share/doc/libicu-dev/examples/uciter8/uit_len8.c \
    ./usr/share/doc/libicu-dev/examples/cal/cal.c \
    ./usr/share/doc/libicu-dev/examples/rules.mk \
    ./usr/include/arm-linux-gnueabihf/unicode/ptypes.h \
    ./usr/share/doc/libicu-dev/examples/strsrch/strsrch.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/uldnames.h \
    ./usr/include/arm-linux-gnueabihf/unicode/selfmt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tmunit.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/answers/main_1.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/Makefile \
    ./usr/share/doc/libicu-dev/examples/cal/cal.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/uciter8/uit_len8.h \
    ./usr/share/doc/libicu-dev/examples/dtitvfmtsample/dtitvfmtsample.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/uscript.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unistr.h \
    ./usr/share/doc/libicu-dev/examples/layout/FontMap.Gnome \
    ./usr/share/doc/libicu-dev/examples/layout/gnomeglue.cpp \
    ./usr/share/doc/libicu-dev/examples/citer/Makefile \
    ./usr/share/doc/libicu-dev/examples/numfmt/numfmt.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/udatpg.h \
    ./usr/share/doc/libicu-dev/examples/date/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/plurfmt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tzfmt.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/util.cpp \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/fortune_resources.mak \
    ./usr/share/doc/libicu-dev/examples/msgfmt/answers/main_0.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/bytestrie.h \
    ./usr/share/doc/libicu-dev/examples/case/case.vcxproj \
    ./usr/lib/arm-linux-gnueabihf/libicutu.a \
    ./usr/include/arm-linux-gnueabihf/unicode/umsg.h \
    ./usr/share/doc/libicu-dev/examples/translit/main.cpp \
    ./usr/share/doc/libicu-dev/examples/ustring/ustring.vcxproj \
    ./usr/share/doc/libicu-dev/examples/break/break.vcxproj \
    ./usr/share/doc/libicu-dev/examples/date/date.vcxproj \
    ./usr/share/doc/libicu-dev/examples/cal/Makefile.in \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/es.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/rbbi.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/data01.txt \
    ./usr/share/doc/libicu-dev/examples/numfmt/capi.c \
    ./usr/include/arm-linux-gnueabihf/unicode/unorm2.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utf8.h \
    ./usr/share/doc/libicu-dev/examples/ustring/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/rbtz.h \
    ./usr/share/doc/libicu-dev/examples/ustring/ustring.cpp \
    ./usr/include/arm-linux-gnueabihf/layout/plruns.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unifunct.h \
    ./usr/share/doc/libicu-dev/examples/break/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/schriter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucnv_cb.h \
    ./usr/include/arm-linux-gnueabihf/unicode/resbund.h \
    ./usr/share/doc/libicu-dev/examples/layout/cmaps.cpp \
    ./usr/include/arm-linux-gnueabihf/layout/ParagraphLayout.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ulocdata.h \
    ./usr/share/doc/libicu-dev/examples/cal/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/dtfmtsym.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucnvsel.h \
    ./usr/include/arm-linux-gnueabihf/unicode/parseerr.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unirepl.h \
    ./usr/include/arm-linux-gnueabihf/unicode/translit.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/answers/main_2.cpp \
    ./usr/share/doc/libicu-dev/examples/cal/uprint.h \
    ./usr/share/doc/libicu-dev/examples/props/props.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/stringpiece.h \
    ./usr/share/doc/libicu-dev/examples/legacy/Makefile \
    ./usr/share/doc/libicu-dev/examples/plurfmtsample/plurfmtsample.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/unum.h \
    ./usr/share/doc/libicu-dev/examples/layout/FontTableCache.h \
    ./usr/share/doc/libicu-dev/examples/cal/readme.txt \
    ./usr/include/arm-linux-gnueabihf/layout/LEInsertionList.h \
    ./usr/share/doc/libicu-dev/examples/layout/GDIFontInstance.cpp \
    ./usr/share/doc/libicu-dev/examples/cal/cal.sln \
    ./usr/share/doc/libicu-dev/examples/ucnv/data06.txt \
    ./usr/share/doc/libicu-dev/examples/datefmt/answers/main_1.cpp \
    ./usr/share/doc/libicu-dev/examples/cal/uprint.c \
    ./usr/include/arm-linux-gnueabihf/layout/LESwaps.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucnv.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tzrule.h \
    ./usr/include/arm-linux-gnueabihf/unicode/platform.h \
    ./usr/share/doc/libicu-dev/examples/break/break.cpp \
    ./usr/lib/arm-linux-gnueabihf/libicui18n.a \
    ./usr/share/doc/libicu-dev/examples/udata/writer.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/csdet/csdet.c \
    ./usr/share/doc/libicu-dev/examples/datefmt/answers/main_3.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/udata.h \
    ./usr/include/arm-linux-gnueabihf/unicode/usetiter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/regex.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unimatch.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ubrk.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ubidi.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uloc.h \
    ./usr/share/doc/libicu-dev/examples/layout/rsurface.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/coll.h \
    ./usr/include/arm-linux-gnueabihf/unicode/localpointer.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uclean.h \
    ./usr/include/arm-linux-gnueabihf/unicode/dtrule.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tmutamt.h \
    ./usr/share/doc/libicu-dev/examples/coll/Makefile \
    ./usr/share/doc/libicu-dev/examples/ugrep/ugrep.cpp \
    ./usr/lib/arm-linux-gnueabihf/icu/current \
    ./usr/share/doc/libicu-dev/examples/layout/ucreader.h \
    ./usr/share/doc/libicu-dev/examples/layout/cgnomelayout.c \
    ./usr/share/doc/libicu-dev/examples/strsrch/Makefile \
    ./usr/share/doc/libicu-dev/examples/ucnv/Makefile \
    ./usr/share/doc/libicu-dev/examples/numfmt/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/icudataver.h \
    ./usr/lib/arm-linux-gnueabihf/libicule.a \
    ./usr/share/doc/libicu-dev/examples/csdet/csdet.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/std_string.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utrans.h \
    ./usr/include/arm-linux-gnueabihf/unicode/vtzone.h \
    ./usr/include/arm-linux-gnueabihf/unicode/numfmt.h \
    ./usr/lib/arm-linux-gnueabihf/libicuuc.a \
    ./usr/include/arm-linux-gnueabihf/unicode/uversion.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utf32.h \
    ./usr/share/icu/52.1/license.html \
    ./usr/include/arm-linux-gnueabihf/unicode/locid.h \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeGUISupport.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/utf16.h \
    ./usr/share/doc/libicu-dev/examples/case/readme.txt \
    ./usr/share/doc/libicu-dev/examples/numfmt/util.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/GDIFontMap.h \
    ./usr/include/arm-linux-gnueabihf/unicode/plurrule.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utf_old.h \
    ./usr/include/arm-linux-gnueabihf/unicode/measure.h \
    ./usr/include/arm-linux-gnueabihf/unicode/parsepos.h \
    ./usr/include/arm-linux-gnueabihf/unicode/stsearch.h \
    ./usr/lib/arm-linux-gnueabihf/libicutest.a \
    ./usr/include/arm-linux-gnueabihf/unicode/gregocal.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucharstriebuilder.h \
    ./usr/share/doc/libicu-dev/examples/layout/sfnt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ustring.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unorm.h \
    ./usr/include/arm-linux-gnueabihf/unicode/messagepattern.h \
    ./usr/share/doc/libicu-dev/examples/dtitvfmtsample/dtitvfmtsample.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/udateintervalformat.h \
    ./usr/include/arm-linux-gnueabihf/unicode/basictz.h \
    ./usr/share/doc/libicu-dev/examples/layout/Makefile.in \
    ./usr/share/doc/libicu-dev/examples/uresb/uresb.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/docmain.h \
    ./usr/share/doc/libicu-dev/examples/citer/citer.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/urename.h \
    ./usr/share/doc/libicu-dev/examples/citer/readme.txt \
    ./usr/share/doc/libicu-dev/examples/layout/paragraph.h \
    ./usr/include/arm-linux-gnueabihf/unicode/bytestriebuilder.h \
    ./usr/share/doc/libicu-dev/examples/dtptngsample/dtptngsample.cpp \
    ./usr/share/doc/libicu-dev/examples/uciter8/uciter8.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/translit/answers/main_2.cpp \
    ./usr/share/doc/libicu-dev/examples/legacy/newcol.cpp \
    ./usr/lib/arm-linux-gnueabihf/libicuio.a \
    ./usr/share/doc/libicu-dev/examples/msgfmt/msgfmt.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/uset.h \
    ./usr/share/doc/libicu-dev/examples/date/date.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/readme.txt \
    ./usr/share/doc/libicu-dev/examples/layout/readme.html \
    ./usr/share/doc/libicu-dev/examples/coll/readme.txt \
    ./usr/share/doc/libicu-dev/examples/datefmt/Makefile \
    ./usr/share/icu/52.1/install-sh \
    ./usr/include/arm-linux-gnueabihf/unicode/numsys.h \
    ./usr/include/arm-linux-gnueabihf/unicode/currunit.h \
    ./usr/share/doc/libicu-dev/examples/datecal/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/stringtriebuilder.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/util.cpp \
    ./usr/share/doc/libicu-dev/examples/break/break.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/layout/FontTableCache.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/uobject.h \
    ./usr/share/doc/libicu-dev/examples/dtitvfmtsample/dtitvfmtsample.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/strsrch/strsrch.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/case/case.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/dtptngsample/dtptngsample.vcxproj \
    ./usr/lib/arm-linux-gnueabihf/libicuuc.so \
    ./usr/share/doc/libicu-dev/examples/udata/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/choicfmt.h \
    ./usr/share/doc/libicu-dev/examples/legacy/README \
    ./usr/share/doc/libicu-dev/examples/case/case.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/ucnv_err.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucharstrie.h \
    ./usr/lib/arm-linux-gnueabihf/libicuio.so \
    ./usr/include/arm-linux-gnueabihf/layout/LETableReference.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ustream.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/ugrep.vcxproj \
    ./usr/share/doc/libicu-dev/examples/uresb/readme.txt \
    ./usr/lib/arm-linux-gnueabihf/libiculx.so \
    ./usr/include/arm-linux-gnueabihf/unicode/uregion.h \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-i18n.pc \
    ./usr/include/arm-linux-gnueabihf/unicode/simpletz.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/datefmt.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/coll/coll.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/calendar.h \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-lx.pc \
    ./usr/share/doc/libicu-dev/examples/ustring/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/usprep.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/util.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/convsamp.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/chariter.h \
    ./usr/share/doc/libicu-dev/examples/break/Makefile \
    ./usr/share/doc/libicu-dev/examples/layout/FontMap.GDI \
    ./usr/share/doc/libicu-dev/examples/datefmt/datefmt.sln \
    ./usr/share/doc/libicu-dev/examples/uresb/uresb.c \
    ./usr/share/doc/libicu-dev/examples/props/props.cpp \
    ./usr/share/doc/libicu-dev/examples/translit/util.h \
    ./usr/share/doc/libicu-dev/examples/numfmt/readme.txt \
    ./usr/share/doc/libicu-dev/examples/layout/GUISupport.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/datefmt.vcxproj \
    ./usr/share/doc/libicu-dev/examples/datefmt/README.TXT \
    ./usr/share/doc/libicu-dev/examples/case/ucase.c \
    ./usr/lib/arm-linux-gnueabihf/icu/pkgdata.inc \
    ./usr/share/doc/libicu-dev/examples/layout/arraymem.h \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-io.pc \
    ./usr/share/doc/libicu-dev/examples/uresb/resources.vcxproj \
    ./usr/lib/arm-linux-gnueabihf/icu/52.1/Makefile.inc \
    ./usr/share/doc/libicu-dev/examples/break/break.sln \
    ./usr/share/doc/libicu-dev/examples/csdet/readme.txt \
    ./usr/share/doc/libicu-dev/examples/layout/gdiglue.cpp \
    ./usr/lib/arm-linux-gnueabihf/libicui18n.so \
    ./usr/include/arm-linux-gnueabihf/unicode/locdspnm.h \
    ./usr/share/doc/libicu-dev/examples/layout/FontMap.h \
    ./usr/share/doc/libicu-dev/examples/layout/GDIGUISupport.cpp \
    ./usr/share/doc/libicu-dev/examples/translit/answers/main_4.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/unumsys.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uvernum.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tznames.h \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/root.txt \
    ./usr/share/doc/libicu-dev/examples/uresb/uresb.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/csdet/Makefile \
    ./usr/share/doc/libicu-dev/examples/ucnv/ucnv.sln \
    ./usr/lib/arm-linux-gnueabihf/icu/Makefile.inc \
    ./usr/share/doc/libicu-dev/examples/date/uprint.h \
    ./usr/share/doc/libicu-dev/examples/layout/layout.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/enumset.h \
    ./usr/share/doc/libicu-dev/examples/layout/Surface.h \
    ./usr/share/doc/libicu-dev/examples/translit/answers/unaccent.h \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeFontMap.cpp \
    ./usr/lib/arm-linux-gnueabihf/libiculx.a \
    ./usr/share/doc/libicu-dev/examples/msgfmt/answers/main_3.cpp \
    ./usr/share/doc/libicu-dev/examples/plurfmtsample/plurfmtsample.vcxproj.filters \
    ./usr/share/icu/52.1/config/mh-linux \
    ./usr/share/doc/libicu-dev/examples/translit/README.TXT \
    ./usr/include/arm-linux-gnueabihf/unicode/utmscale.h \
    ./usr/share/doc/libicu-dev/examples/citer/citer.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/unifilt.h \
    ./usr/share/doc/libicu-dev/examples/props/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/measfmt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uspoof.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/msgfmt.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/errorcode.h \
    ./usr/share/doc/libicu-dev/examples/plurfmtsample/plurfmtsample.cpp \
    ./usr/share/doc/libicu-dev/examples/numfmt/main.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/dtintrv.h \
    ./usr/share/doc/libicu-dev/examples/props/props.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/dbbi.h \
    ./usr/include/arm-linux-gnueabihf/unicode/dtitvfmt.h \
    ./usr/share/doc/libicu-dev/examples/coll/coll.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/layout/gnomelayout.cpp \
    ./usr/share/doc/libicu-dev/examples/uresb/uresb.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/tmutfmt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/datefmt.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/ugrep.sln \
    ./usr/share/doc/libicu-dev/examples/ugrep/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/rbnf.h \
    ./usr/include/arm-linux-gnueabihf/unicode/normlzr.h \
    ./usr/include/arm-linux-gnueabihf/unicode/curramt.h \
    ./usr/share/doc/libicu-dev/examples/layout/LayoutSample.rc \
    ./usr/share/doc/libicu-dev/examples/udata/writer.c\
"
FILES_libicu52 = " \
    ./usr/lib/arm-linux-gnueabihf/libicui18n.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libicudata.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libicutest.so.52.1 \
    ./usr/share/doc/libicu52/NEWS.Debian.gz \
    ./usr/lib/arm-linux-gnueabihf/libiculx.so.52.1 \
    ./usr/share/lintian/overrides/libicu52 \
    ./usr/lib/arm-linux-gnueabihf/libiculx.so.52 \
    ./usr/share/doc/libicu52/copyright \
    ./usr/lib/arm-linux-gnueabihf/libicutest.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicuuc.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicutu.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicuio.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libicule.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicudata.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicui18n.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicutu.so.52.1 \
    ./usr/share/doc/libicu52/changelog.Debian.gz \
    ./usr/lib/arm-linux-gnueabihf/libicuio.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicule.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libicuuc.so.52.1\
"
#FAKE LICENSE FOR TESTING!!!
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"
