PACKAGES = "${PN} icu-devtools libicu-dev libicu52"
PROVIDES = "icu-devtools libicu-dev libicu52"
SRC_URI = " \
	http://archive.raspbian.org/raspbian/pool/main/i/icu/icu-devtools_52.1-8+deb8u6_armhf.deb;unpack=0;name=deb0\
	http://archive.raspbian.org/raspbian/pool/main/i/icu/libicu-dev_52.1-8+deb8u6_armhf.deb;unpack=0;name=deb1\
	http://archive.raspbian.org/raspbian/pool/main/i/icu/libicu52_52.1-8+deb8u6_armhf.deb;unpack=0;name=deb2\
"
DEBFILENAME_icu-devtools = "icu-devtools_52.1-8+deb8u6_armhf.deb"
SRC_URI[deb0.sha256sum] = "98680f55089dc6aac85c23a720fab55529d294754b480c0c389903cec80edcaf"
SRC_URI[deb0.md5sum] = "7cca5369005864d6bd4cc88a55e3c3ad"
DEBFILENAME_libicu-dev = "libicu-dev_52.1-8+deb8u6_armhf.deb"
SRC_URI[deb1.sha256sum] = "73588062a83397c557c98c0a895786549ad91ef08d85ec69f9978247d4a6174a"
SRC_URI[deb1.md5sum] = "a2784fd428f95df392cf21b4a234bd73"
DEBFILENAME_libicu52 = "libicu52_52.1-8+deb8u6_armhf.deb"
SRC_URI[deb2.sha256sum] = "13eb283982840e0349e539956f646c5c70fdaebadbcdac7817270a3d07c86018"
SRC_URI[deb2.md5sum] = "52eb05cd2f032449dc12d57aa9ac25c1"

RDEPENDS_${PN}-devtools = "libc6 (>= 2.4) libgcc1 (>= 1:4.4.0) libicu52 (>= 52~m1-1~) libstdc++6 (>= 4.9)"
RDEPENDS_lib${PN}-dev = "libicu52 (= 52.1-8+deb8u6) icu-devtools (>= 52.1-8+deb8u6) libc6-dev"
RDEPENDS_lib${PN}52 = "libc6 (>= 2.7) libgcc1 (>= 1:4.4.0) libstdc++6 (>= 4.9)"
DEPENDS = "libgcc1 libstdc++6 libc6 libc6-dev"


inherit deb_group

# Prebuilt binaries, no need for any default dependencies
INHIBIT_DEFAULT_DEPS = "1"
INHIBIT_PACKAGE_STRIP = "1"
INSANE_SKIP_${PN} += "already-stripped"

FILES_icu-devtools = " \
    ./usr/share/man/man1/icuinfo.1.gz \
    ./usr/share/man/man1/genrb.1.gz \
    ./usr/share/man/man1/gencnval.1.gz \
    ./usr/bin/derb \
    ./usr/bin/genrb \
    ./usr/share/doc/icu-devtools/NEWS.Debian.gz \
    ./usr/share/man/man1/gencfu.1.gz \
    ./usr/share/man/man1/makeconv.1.gz \
    ./usr/bin/makeconv \
    ./usr/bin/gencfu \
    ./usr/share/doc/icu-devtools/changelog.Debian.gz \
    ./usr/share/doc/icu-devtools/copyright \
    ./usr/bin/gencnval \
    ./usr/share/man/man1/icu-config.1.gz \
    ./usr/share/man/man8/icupkg.8.gz \
    ./usr/sbin/genccode \
    ./usr/bin/uconv \
    ./usr/bin/genbrk \
    ./usr/sbin/gennorm2 \
    ./usr/bin/icu-config \
    ./usr/bin/icuinfo \
    ./usr/share/man/man1/uconv.1.gz \
    ./usr/share/man/man1/gendict.1.gz \
    ./usr/share/man/man8/gencmn.8.gz \
    ./usr/share/man/man1/pkgdata.1.gz \
    ./usr/sbin/icupkg \
    ./usr/share/man/man1/derb.1.gz \
    ./usr/sbin/gencmn \
    ./usr/sbin/gensprep \
    ./usr/bin/pkgdata \
    ./usr/bin/gendict \
    ./usr/share/man/man8/gennorm2.8.gz \
    ./usr/share/man/man8/genccode.8.gz \
    ./usr/share/man/man8/gensprep.8.gz \
    ./usr/share/man/man1/genbrk.1.gz\
"
FILES_libicu-dev = " \
    ./usr/share/doc/libicu-dev/examples/layout/cmaps.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tzrule.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/msgfmt.sln \
    ./usr/share/doc/libicu-dev/examples/ucnv/flagcb.h \
    ./usr/share/doc/libicu-dev/examples/uciter8/uciter8.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/translit.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utext.h \
    ./usr/share/doc/libicu-dev/examples/citer/citer.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/FontTableCache.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/uidna.h \
    ./usr/share/doc/libicu-dev/examples/layout/FontMap.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/ucnv.sln \
    ./usr/share/doc/libicu-dev/examples/date/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/unifunct.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucnv_cb.h \
    ./usr/share/doc/libicu-dev/examples/legacy/legacy.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/ucnv.h \
    ./usr/include/arm-linux-gnueabihf/unicode/strenum.h \
    ./usr/include/arm-linux-gnueabihf/unicode/fmtable.h \
    ./usr/share/doc/libicu-dev/examples/layout/FontMap.Gnome \
    ./usr/include/arm-linux-gnueabihf/unicode/umisc.h \
    ./usr/share/doc/libicu-dev/examples/legacy/README \
    ./usr/lib/arm-linux-gnueabihf/libicui18n.so \
    ./usr/include/arm-linux-gnueabihf/unicode/ushape.h \
    ./usr/include/arm-linux-gnueabihf/unicode/stsearch.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uregion.h \
    ./usr/share/doc/libicu-dev/examples/strsrch/strsrch.vcxproj \
    ./usr/include/arm-linux-gnueabihf/layout/LEGlyphFilter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/rbtz.h \
    ./usr/share/doc/libicu-dev/examples/props/props.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/udata/reader.c \
    ./usr/include/arm-linux-gnueabihf/unicode/tmutfmt.h \
    ./usr/share/doc/libicu-dev/examples/csdet/Makefile \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/root.txt \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeGUISupport.cpp \
    ./usr/share/doc/libicu-dev/examples/uciter8/uciter8.sln \
    ./usr/share/doc/libicu-dev/examples/numfmt/numfmt.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/citer/citer.vcxproj \
    ./usr/share/doc/libicu-dev/examples/citer/readme.txt \
    ./usr/share/doc/libicu-dev/examples/layout/ScriptCompositeFontInstance.cpp \
    ./usr/share/doc/libicu-dev/examples/props/props.sln \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-uc.pc \
    ./usr/include/arm-linux-gnueabihf/unicode/uchriter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/urep.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uconfig.h \
    ./usr/share/doc/libicu-dev/examples/date/date.c \
    ./usr/share/doc/libicu-dev/examples/uresb/Makefile \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-lx.pc \
    ./usr/share/doc/libicu-dev/examples/case/readme.txt \
    ./usr/share/doc/libicu-dev/examples/props/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/unirepl.h \
    ./usr/share/doc/libicu-dev/examples/uresb/resources.mak \
    ./usr/include/arm-linux-gnueabihf/unicode/errorcode.h \
    ./usr/share/doc/libicu-dev/examples/legacy/Makefile \
    ./usr/share/doc/libicu-dev/examples/ustring/ustring.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/ucnvsel.h \
    ./usr/share/doc/libicu-dev/examples/layout/pflow.c \
    ./usr/share/doc/libicu-dev/examples/uresb/root.txt \
    ./usr/share/doc/libicu-dev/examples/layout/layout.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/dbbi.h \
    ./usr/share/doc/libicu-dev/examples/break/break.cpp \
    ./usr/share/doc/libicu-dev/examples/plurfmtsample/plurfmtsample.cpp \
    ./usr/share/doc/libicu-dev/examples/break/ubreak.c \
    ./usr/include/arm-linux-gnueabihf/unicode/measunit.h \
    ./usr/include/arm-linux-gnueabihf/unicode/upluralrules.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/answers/main_0.cpp \
    ./usr/lib/arm-linux-gnueabihf/libicuuc.a \
    ./usr/include/arm-linux-gnueabihf/unicode/dtptngen.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/convsamp.cpp \
    ./usr/share/doc/libicu-dev/examples/ufortune/readme.txt \
    ./usr/share/doc/libicu-dev/examples/translit/unaccent.cpp \
    ./usr/lib/arm-linux-gnueabihf/libiculx.so \
    ./usr/share/doc/libicu-dev/examples/layout/gdiglue.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uvernum.h \
    ./usr/include/arm-linux-gnueabihf/unicode/coleitr.h \
    ./usr/include/arm-linux-gnueabihf/unicode/vtzone.h \
    ./usr/share/doc/libicu-dev/examples/strsrch/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/uversion.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucat.h \
    ./usr/include/arm-linux-gnueabihf/layout/LEFontInstance.h \
    ./usr/include/arm-linux-gnueabihf/unicode/enumset.h \
    ./usr/share/doc/libicu-dev/examples/uciter8/uit_len8.c \
    ./usr/share/doc/libicu-dev/examples/layout/ucreader.cpp \
    ./usr/include/arm-linux-gnueabihf/layout/loengine.h \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeFontInstance.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/unumsys.h \
    ./usr/share/doc/libicu-dev/changelog.Debian.gz \
    ./usr/share/doc/libicu-dev/examples/layout/gsupport.h \
    ./usr/share/doc/libicu-dev/examples/numfmt/util.cpp \
    ./usr/share/doc/libicu-dev/examples/legacy/legacy.vcxproj \
    ./usr/share/doc/libicu-dev/examples/coll/coll.vcxproj \
    ./usr/share/doc/libicu-dev/examples/translit/util.cpp \
    ./usr/share/doc/libicu-dev/examples/case/Makefile \
    ./usr/share/icu/52.1/license.html \
    ./usr/include/arm-linux-gnueabihf/unicode/ubidi.h \
    ./usr/lib/arm-linux-gnueabihf/libicutu.a \
    ./usr/include/arm-linux-gnueabihf/unicode/messagepattern.h \
    ./usr/share/doc/libicu-dev/examples/layout/GUISupport.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucharstriebuilder.h \
    ./usr/include/arm-linux-gnueabihf/unicode/simpletz.h \
    ./usr/share/doc/libicu-dev/examples/translit/translit.sln \
    ./usr/include/arm-linux-gnueabihf/layout/plruns.h \
    ./usr/share/doc/libicu-dev/examples/uresb/uresb.vcxproj \
    ./usr/share/doc/libicu-dev/examples/numfmt/capi.c \
    ./usr/share/doc/libicu-dev/examples/translit/translit.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/numsys.h \
    ./usr/share/doc/libicu-dev/examples/break/Makefile \
    ./usr/share/doc/libicu-dev/examples/translit/answers/main_2.cpp \
    ./usr/share/doc/libicu-dev/examples/uciter8/Makefile \
    ./usr/share/doc/libicu-dev/examples/strsrch/strsrch.sln \
    ./usr/share/doc/libicu-dev/examples/datefmt/answers/main_1.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/Makefile.in \
    ./usr/share/doc/libicu-dev/examples/ufortune/ufortune.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/Makefile \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/fortune_resources.mak \
    ./usr/share/doc/libicu-dev/examples/layout/FontTableCache.h \
    ./usr/include/arm-linux-gnueabihf/unicode/gender.h \
    ./usr/share/doc/libicu-dev/examples/translit/answers/main_1.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/cmaps.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/tmutamt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uloc.h \
    ./usr/share/doc/libicu-dev/examples/layout/resource.h \
    ./usr/share/doc/libicu-dev/examples/dtitvfmtsample/dtitvfmtsample.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/Makefile.in \
    ./usr/share/doc/libicu-dev/examples/layout/Sample.txt \
    ./usr/share/doc/libicu-dev/examples/translit/answers/unaccent.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/Makefile \
    ./usr/lib/arm-linux-gnueabihf/libicule.a \
    ./usr/include/arm-linux-gnueabihf/unicode/smpdtfmt.h \
    ./usr/share/doc/libicu-dev/examples/break/break.vcxproj \
    ./usr/share/doc/libicu-dev/examples/datefmt/util.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/urename.h \
    ./usr/share/doc/libicu-dev/examples/layout/gnomelayout.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/udata.h \
    ./usr/include/arm-linux-gnueabihf/unicode/usetiter.h \
    ./usr/share/doc/libicu-dev/examples/datecal/cal.cpp \
    ./usr/include/arm-linux-gnueabihf/layout/LEGlyphStorage.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ustringtrie.h \
    ./usr/lib/arm-linux-gnueabihf/libicutest.so \
    ./usr/include/arm-linux-gnueabihf/unicode/compactdecimalformat.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uclean.h \
    ./usr/include/arm-linux-gnueabihf/unicode/dtintrv.h \
    ./usr/share/doc/libicu-dev/examples/translit/translit.vcxproj \
    ./usr/share/doc/libicu-dev/examples/layout/RenderingSurface.h \
    ./usr/share/doc/libicu-dev/examples/uciter8/uciter8.vcxproj \
    ./usr/share/doc/libicu-dev/examples/coll/coll.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeFontMap.cpp \
    ./usr/share/doc/libicu-dev/examples/msgfmt/main.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/gnomeglue.cpp \
    ./usr/share/doc/libicu-dev/examples/dtitvfmtsample/dtitvfmtsample.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/ucsdet.h \
    ./usr/share/doc/libicu-dev/examples/ustring/ustring.vcxproj.filters \
    ./usr/lib/arm-linux-gnueabihf/icu/52.1/pkgdata.inc \
    ./usr/include/arm-linux-gnueabihf/unicode/region.h \
    ./usr/include/arm-linux-gnueabihf/unicode/brkiter.h \
    ./usr/share/doc/libicu-dev/examples/case/case.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/layout/UnicodeReader.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/platform.h \
    ./usr/share/doc/libicu-dev/examples/props/props.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/coll.h \
    ./usr/include/arm-linux-gnueabihf/unicode/currpinf.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/ugrep.cpp \
    ./usr/share/doc/libicu-dev/examples/dtptngsample/dtptngsample.cpp \
    ./usr/share/doc/libicu-dev/examples/udata/writer.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/datefmt/datefmt.vcxproj \
    ./usr/share/doc/libicu-dev/examples/udata/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/utf.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utrans.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tmunit.h \
    ./usr/include/arm-linux-gnueabihf/unicode/putil.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/util.cpp \
    ./usr/share/doc/libicu-dev/examples/ufortune/ufortune.c \
    ./usr/share/doc/libicu-dev/examples/datefmt/answers/main_3.cpp \
    ./usr/share/doc/libicu-dev/examples/translit/answers/unaccent.cpp \
    ./usr/share/doc/libicu-dev/examples/udata/reader.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/ucnv/flagcb.c \
    ./usr/share/doc/libicu-dev/examples/uciter8/uciter8.c \
    ./usr/share/doc/libicu-dev/examples/strsrch/strsrch.cpp \
    ./usr/share/doc/libicu-dev/examples/cal/cal.sln \
    ./usr/share/doc/libicu-dev/examples/citer/citer.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/layout/layout.vcxproj \
    ./usr/share/doc/libicu-dev/examples/plurfmtsample/plurfmtsample.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/stringtriebuilder.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/ugrep.vcxproj \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-i18n.pc \
    ./usr/share/doc/libicu-dev/examples/numfmt/util.h \
    ./usr/share/doc/libicu-dev/examples/numfmt/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/listformatter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unistr.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uset.h \
    ./usr/share/doc/libicu-dev/examples/layout/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/appendable.h \
    ./usr/share/doc/libicu-dev/examples/ustring/Makefile \
    ./usr/share/doc/libicu-dev/NEWS.Debian.gz \
    ./usr/include/arm-linux-gnueabihf/unicode/unorm2.h \
    ./usr/include/arm-linux-gnueabihf/unicode/udat.h \
    ./usr/share/doc/libicu-dev/examples/layout/ucreader.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ubrk.h \
    ./usr/share/doc/libicu-dev/examples/legacy/legacy.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/translit/main.cpp \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/res-file-list.txt \
    ./usr/share/doc/libicu-dev/examples/uresb/resources.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/regex.h \
    ./usr/share/doc/libicu-dev/examples/defs.mk \
    ./usr/share/doc/libicu-dev/examples/layout/rsurface.h \
    ./usr/share/doc/libicu-dev/examples/cal/Makefile \
    ./usr/share/doc/libicu-dev/examples/rules.mk \
    ./usr/share/doc/libicu-dev/examples/cal/cal.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/tznames.h \
    ./usr/share/doc/libicu-dev/examples/date/date.vcxproj \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeGUISupport.h \
    ./usr/include/arm-linux-gnueabihf/unicode/schriter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uobject.h \
    ./usr/include/arm-linux-gnueabihf/layout/LESwaps.h \
    ./usr/share/doc/libicu-dev/examples/udata/writer.c \
    ./usr/include/arm-linux-gnueabihf/unicode/ucal.h \
    ./usr/include/arm-linux-gnueabihf/unicode/rbbi.h \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeFontMap.h \
    ./usr/include/arm-linux-gnueabihf/unicode/decimfmt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/fpositer.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/README.TXT \
    ./usr/share/doc/libicu-dev/examples/layout/ScriptCompositeFontInstance.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uregex.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucol.h \
    ./usr/include/arm-linux-gnueabihf/layout/LEScripts.h \
    ./usr/share/doc/libicu-dev/copyright \
    ./usr/include/arm-linux-gnueabihf/unicode/choicfmt.h \
    ./usr/share/doc/libicu-dev/examples/layout/GnomeFontInstance.h \
    ./usr/share/doc/libicu-dev/examples/layout/paragraph.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/GDIFontInstance.cpp \
    ./usr/share/doc/libicu-dev/examples/datecal/Makefile \
    ./usr/lib/arm-linux-gnueabihf/libicui18n.a \
    ./usr/include/arm-linux-gnueabihf/unicode/utf8.h \
    ./usr/lib/arm-linux-gnueabihf/icu/current \
    ./usr/include/arm-linux-gnueabihf/unicode/utrace.h \
    ./usr/lib/arm-linux-gnueabihf/libicule.so \
    ./usr/share/doc/libicu-dev/examples/plurfmtsample/plurfmtsample.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/stringpiece.h \
    ./usr/include/arm-linux-gnueabihf/unicode/datefmt.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/Makefile \
    ./usr/share/doc/libicu-dev/examples/legacy/oldcol.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/uscript.h \
    ./usr/include/arm-linux-gnueabihf/unicode/fieldpos.h \
    ./usr/include/arm-linux-gnueabihf/unicode/tzfmt.h \
    ./usr/share/doc/libicu-dev/examples/layout/rsurface.cpp \
    ./usr/share/doc/libicu-dev/examples/all/all.sln \
    ./usr/share/doc/libicu-dev/examples/coll/readme.txt \
    ./usr/share/doc/libicu-dev/examples/date/uprint.c \
    ./usr/share/doc/libicu-dev/examples/uciter8/readme.txt \
    ./usr/share/doc/libicu-dev/examples/cal/uprint.c \
    ./usr/share/doc/libicu-dev/examples/numfmt/readme.txt \
    ./usr/share/doc/libicu-dev/examples/msgfmt/msgfmt.vcxproj \
    ./usr/include/arm-linux-gnueabihf/layout/LETypes.h \
    ./usr/share/doc/libicu-dev/examples/udata/udata.sln \
    ./usr/lib/arm-linux-gnueabihf/libicutu.so \
    ./usr/share/doc/libicu-dev/examples/dtptngsample/dtptngsample.vcxproj \
    ./usr/share/doc/libicu-dev/examples/csdet/readme.txt \
    ./usr/share/doc/libicu-dev/examples/case/case.sln \
    ./usr/share/doc/libicu-dev/examples/translit/answers/main_3.cpp \
    ./usr/share/doc/libicu-dev/examples/datefmt/answers/main_2.cpp \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-io.pc \
    ./usr/include/arm-linux-gnueabihf/unicode/normalizer2.h \
    ./usr/share/doc/libicu-dev/examples/case/case.vcxproj \
    ./usr/share/doc/libicu-dev/examples/csdet/csdet.c \
    ./usr/share/doc/libicu-dev/examples/datefmt/datefmt.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/uchar.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uenum.h \
    ./usr/share/doc/libicu-dev/examples/layout/clayout.c \
    ./usr/include/arm-linux-gnueabihf/layout/RunArrays.h \
    ./usr/include/arm-linux-gnueabihf/unicode/gregocal.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ugender.h \
    ./usr/include/arm-linux-gnueabihf/unicode/udisplaycontext.h \
    ./usr/share/doc/libicu-dev/examples/cal/uprint.h \
    ./usr/lib/arm-linux-gnueabihf/libicuio.a \
    ./usr/include/arm-linux-gnueabihf/unicode/format.h \
    ./usr/share/doc/libicu-dev/examples/layout/Surface.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/uformattable.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucoleitr.h \
    ./usr/include/arm-linux-gnueabihf/layout/LELanguages.h \
    ./usr/lib/arm-linux-gnueabihf/libicuio.so \
    ./usr/include/arm-linux-gnueabihf/unicode/ucasemap.h \
    ./usr/share/doc/libicu-dev/examples/props/readme.txt \
    ./usr/share/doc/libicu-dev/examples/layout/layout.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/locdspnm.h \
    ./usr/lib/arm-linux-gnueabihf/icu/pkgdata.inc \
    ./usr/lib/arm-linux-gnueabihf/libicudata.a \
    ./usr/include/arm-linux-gnueabihf/unicode/tblcoll.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utypes.h \
    ./usr/share/doc/libicu-dev/examples/citer/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/currunit.h \
    ./usr/include/arm-linux-gnueabihf/unicode/dtitvfmt.h \
    ./usr/share/doc/libicu-dev/examples/translit/unaccent.h \
    ./usr/share/doc/libicu-dev/examples/ufortune/ufortune.sln \
    ./usr/share/doc/libicu-dev/examples/layout/LayoutSample.rc \
    ./usr/include/arm-linux-gnueabihf/unicode/rbnf.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uspoof.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/data01.txt \
    ./usr/share/doc/libicu-dev/examples/ucnv/ucnv.vcxproj \
    ./usr/lib/arm-linux-gnueabihf/libicudata.so \
    ./usr/lib/arm-linux-gnueabihf/libicuuc.so \
    ./usr/share/doc/libicu-dev/examples/datefmt/README.TXT \
    ./usr/share/doc/libicu-dev/examples/date/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/usprep.h \
    ./usr/share/doc/libicu-dev/examples/uresb/resources.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/curramt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/dtfmtsym.h \
    ./usr/lib/arm-linux-gnueabihf/icu/52.1/Makefile.inc \
    ./usr/share/doc/libicu-dev/examples/ufortune/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/udateintervalformat.h \
    ./usr/share/doc/libicu-dev/examples/props/props.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/bytestream.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ures.h \
    ./usr/include/arm-linux-gnueabihf/unicode/plurfmt.h \
    ./usr/share/doc/libicu-dev/examples/translit/README.TXT \
    ./usr/share/doc/libicu-dev/examples/ucnv/ucnv.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/layout/Surface.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucharstrie.h \
    ./usr/include/arm-linux-gnueabihf/unicode/chariter.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/Makefile \
    ./usr/share/icu/52.1/config/mh-linux \
    ./usr/share/doc/libicu-dev/examples/csdet/csdet.vcxproj \
    ./usr/include/arm-linux-gnueabihf/layout/LayoutEngine.h \
    ./usr/share/doc/libicu-dev/examples/coll/coll.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/layout/GDIGUISupport.h \
    ./usr/include/arm-linux-gnueabihf/unicode/bytestrie.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/data06.txt \
    ./usr/share/doc/libicu-dev/examples/layout/gnomeglue.h \
    ./usr/share/doc/libicu-dev/examples/layout/gdiglue.cpp \
    ./usr/share/doc/libicu-dev/examples/layout/GDIFontMap.h \
    ./usr/share/doc/libicu-dev/examples/udata/reader.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/locid.h \
    ./usr/include/arm-linux-gnueabihf/unicode/plurrule.h \
    ./usr/include/arm-linux-gnueabihf/unicode/udatpg.h \
    ./usr/share/doc/libicu-dev/examples/datefmt/util.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ustdio.h \
    ./usr/share/doc/libicu-dev/examples/cal/Makefile.in \
    ./usr/include/arm-linux-gnueabihf/layout/playout.h \
    ./usr/share/doc/libicu-dev/examples/dtptngsample/dtptngsample.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/datefmt/main.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/ptypes.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/util.h \
    ./usr/include/arm-linux-gnueabihf/unicode/icuplug.h \
    ./usr/share/doc/libicu-dev/examples/translit/Makefile \
    ./usr/lib/arm-linux-gnueabihf/pkgconfig/icu-le.pc \
    ./usr/share/doc/libicu-dev/examples/udata/writer.vcxproj \
    ./usr/share/doc/libicu-dev/examples/legacy/legacy.sln \
    ./usr/share/doc/libicu-dev/examples/strsrch/Makefile \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/Makefile \
    ./usr/share/doc/libicu-dev/examples/layout/FontMap.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/sortkey.h \
    ./usr/share/doc/libicu-dev/examples/ucnv/readme.txt \
    ./usr/share/doc/libicu-dev/examples/msgfmt/answers/main_3.cpp \
    ./usr/share/doc/libicu-dev/examples/msgfmt/msgfmt.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/layout/LETableReference.h \
    ./usr/share/doc/libicu-dev/examples/uresb/uresb.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/translit/answers/main_4.cpp \
    ./usr/share/doc/libicu-dev/examples/uresb/uresb.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/measfmt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uniset.h \
    ./usr/share/doc/libicu-dev/examples/coll/Makefile \
    ./usr/share/doc/libicu-dev/examples/ustring/ustring.cpp \
    ./usr/share/doc/libicu-dev/examples/ustring/readme.txt \
    ./usr/share/doc/libicu-dev/examples/uresb/en.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/resbund.h \
    ./usr/share/doc/libicu-dev/examples/cal/cal.c \
    ./usr/include/arm-linux-gnueabihf/unicode/parsepos.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unifilt.h \
    ./usr/include/arm-linux-gnueabihf/layout/ParagraphLayout.h \
    ./usr/share/doc/libicu-dev/examples/numfmt/numfmt.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/umachine.h \
    ./usr/share/doc/libicu-dev/examples/layout/layout.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/datefmt/datefmt.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/alphaindex.h \
    ./usr/share/doc/libicu-dev/examples/layout/GDIFontMap.cpp \
    ./usr/share/doc/libicu-dev/examples/ufortune/resources/es.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/timezone.h \
    ./usr/share/doc/libicu-dev/examples/date/Makefile.in \
    ./usr/share/doc/libicu-dev/examples/dtitvfmtsample/dtitvfmtsample.cpp \
    ./usr/share/doc/libicu-dev/examples/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/ustring.h \
    ./usr/share/doc/libicu-dev/examples/break/readme.txt \
    ./usr/share/doc/libicu-dev/examples/ucnv/data02.bin \
    ./usr/share/doc/libicu-dev/examples/layout/paragraph.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utf32.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unorm.h \
    ./usr/share/doc/libicu-dev/examples/break/break.sln \
    ./usr/share/doc/libicu-dev/examples/layout/FontMap.GDI \
    ./usr/share/doc/libicu-dev/examples/date/date.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/unimatch.h \
    ./usr/share/doc/libicu-dev/examples/ufortune/fortunedefs.mk \
    ./usr/include/arm-linux-gnueabihf/unicode/ucnv_err.h \
    ./usr/share/doc/libicu-dev/examples/cal/cal.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/uciter8/uit_len8.h \
    ./usr/include/arm-linux-gnueabihf/unicode/msgfmt.h \
    ./usr/include/arm-linux-gnueabihf/layout/LEInsertionList.h \
    ./usr/share/doc/libicu-dev/examples/layout/GDIFontInstance.h \
    ./usr/include/arm-linux-gnueabihf/unicode/parseerr.h \
    ./usr/include/arm-linux-gnueabihf/unicode/std_string.h \
    ./usr/share/doc/libicu-dev/examples/uresb/uresb.c \
    ./usr/share/doc/libicu-dev/examples/coll/coll.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/ustream.h \
    ./usr/share/doc/libicu-dev/examples/date/date.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/bytestriebuilder.h \
    ./usr/share/doc/libicu-dev/examples/layout/readme.html \
    ./usr/share/doc/libicu-dev/examples/cal/readme.txt \
    ./usr/include/arm-linux-gnueabihf/unicode/utf_old.h \
    ./usr/share/doc/libicu-dev/examples/udata/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/ulocdata.h \
    ./usr/include/arm-linux-gnueabihf/unicode/utf16.h \
    ./usr/include/arm-linux-gnueabihf/unicode/docmain.h \
    ./usr/include/arm-linux-gnueabihf/unicode/ucurr.h \
    ./usr/share/icu/52.1/install-sh \
    ./usr/share/doc/libicu-dev/examples/break/break.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/rep.h \
    ./usr/include/arm-linux-gnueabihf/unicode/measure.h \
    ./usr/share/doc/libicu-dev/examples/layout/sfnt.h \
    ./usr/share/doc/libicu-dev/examples/translit/util.h \
    ./usr/include/arm-linux-gnueabihf/unicode/umsg.h \
    ./usr/include/arm-linux-gnueabihf/unicode/uiter.h \
    ./usr/lib/arm-linux-gnueabihf/icu/Makefile.inc \
    ./usr/share/doc/libicu-dev/examples/numfmt/numfmt.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/normlzr.h \
    ./usr/share/doc/libicu-dev/examples/numfmt/main.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/search.h \
    ./usr/share/doc/libicu-dev/examples/ufortune/ufortune.vcxproj \
    ./usr/include/arm-linux-gnueabihf/unicode/calendar.h \
    ./usr/include/arm-linux-gnueabihf/unicode/unum.h \
    ./usr/share/doc/libicu-dev/examples/layout/UnicodeReader.h \
    ./usr/share/doc/libicu-dev/examples/uresb/readme.txt \
    ./usr/share/doc/libicu-dev/examples/date/uprint.h \
    ./usr/share/doc/libicu-dev/examples/strsrch/strsrch.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/ustring/ustring.vcxproj \
    ./usr/share/doc/libicu-dev/examples/msgfmt/Makefile \
    ./usr/include/arm-linux-gnueabihf/unicode/uldnames.h \
    ./usr/share/icu/52.1/mkinstalldirs \
    ./usr/include/arm-linux-gnueabihf/unicode/numfmt.h \
    ./usr/share/doc/libicu-dev/examples/layout/GDIGUISupport.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/dtitvinf.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/readme.txt \
    ./usr/lib/arm-linux-gnueabihf/libicutest.a \
    ./usr/include/arm-linux-gnueabihf/unicode/tztrans.h \
    ./usr/include/arm-linux-gnueabihf/unicode/dcfmtsym.h \
    ./usr/share/doc/libicu-dev/examples/layout/arraymem.h \
    ./usr/share/doc/libicu-dev/examples/uresb/sr.txt \
    ./usr/share/doc/libicu-dev/examples/legacy/newcol.cpp \
    ./usr/share/doc/libicu-dev/examples/datecal/ccal.c \
    ./usr/share/doc/libicu-dev/examples/case/case.cpp \
    ./usr/share/doc/libicu-dev/examples/msgfmt/answers/main_2.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/caniter.h \
    ./usr/include/arm-linux-gnueabihf/unicode/localpointer.h \
    ./usr/share/doc/libicu-dev/examples/csdet/csdet.vcxproj.filters \
    ./usr/include/arm-linux-gnueabihf/unicode/basictz.h \
    ./usr/include/arm-linux-gnueabihf/unicode/selfmt.h \
    ./usr/include/arm-linux-gnueabihf/unicode/usearch.h \
    ./usr/include/arm-linux-gnueabihf/unicode/dtrule.h \
    ./usr/include/arm-linux-gnueabihf/unicode/icudataver.h \
    ./usr/lib/arm-linux-gnueabihf/libiculx.a \
    ./usr/share/doc/libicu-dev/examples/layout/cgnomelayout.c \
    ./usr/include/arm-linux-gnueabihf/unicode/idna.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/ugrep.sln \
    ./usr/include/arm-linux-gnueabihf/unicode/symtable.h \
    ./usr/share/doc/libicu-dev/examples/ugrep/ugrep.vcxproj.filters \
    ./usr/share/doc/libicu-dev/examples/msgfmt/answers/main_1.cpp \
    ./usr/include/arm-linux-gnueabihf/unicode/utmscale.h \
    ./usr/share/doc/libicu-dev/examples/msgfmt/answers/main_0.cpp \
    ./usr/share/doc/libicu-dev/examples/case/ucase.c \
    ./usr/share/doc/libicu-dev/examples/layout/pflow.h\
"
FILES_libicu52 = " \
    ./usr/lib/arm-linux-gnueabihf/libicui18n.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libicuuc.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libicule.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libiculx.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicuuc.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicui18n.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicudata.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicutu.so.52.1 \
    ./usr/share/doc/libicu52/NEWS.Debian.gz \
    ./usr/lib/arm-linux-gnueabihf/libiculx.so.52.1 \
    ./usr/share/doc/libicu52/changelog.Debian.gz \
    ./usr/lib/arm-linux-gnueabihf/libicutest.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libicule.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicudata.so.52.1 \
    ./usr/lib/arm-linux-gnueabihf/libicuio.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicutu.so.52 \
    ./usr/share/doc/libicu52/copyright \
    ./usr/share/lintian/overrides/libicu52 \
    ./usr/lib/arm-linux-gnueabihf/libicutest.so.52 \
    ./usr/lib/arm-linux-gnueabihf/libicuio.so.52.1\
"
#FAKE LICENSE FOR TESTING!!!
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"
